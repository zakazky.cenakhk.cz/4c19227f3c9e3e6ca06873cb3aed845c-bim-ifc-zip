Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: a70d0573-3d5e-4999-99f6-eda5486a8d62, NumberOfSaves: 106], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-10-17T17:13:50+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (CSY) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:#Hlavní (2)
Name | LongName | Elevation (mm)
B.p.v | B.p.v | 0
1NP | 1NP | 439500

# IfcGeographicElement: #Strom:#Odstraněný strom (101)
In: 1NP
Type - Material: #Strom
Type - CZ_DTcommon - DT_name: odstraňování a ořezávání stromů a keřů
Type - CZ_ElementCommon - ElementProjectSpecificName: #Odstraněný strom; ElementProjectSpecificDescription: Ostraněná zeleň; ElementProjectSpecificIdentifier: STR01
Type - CZ_CCI - CCI_FunctionalSystemsCode: A; CCI_TechnicalSystemsCode: RA; CCI_ComponentsCode: TRA
CZ_ElementCommon - ElementProjectObjectIdentifier: IO 800; StoreyProjectSpecificIdentifier: 1NP; sets with these values: 2
Qto_BuildingBaseQuantities - sets with these values: 2
Name (#Strom:#Odstraněný strom:...) | Pset_SiteCommon, Reference | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | NetFloorArea
187866 | Populus tremula | STR01.187866 | 135 | 113,10 m²
187877 | Betula pendula | STR01.187877 | 215 | 63,62 m²
187878 | Larix decidua | STR01.187878 | 214 | 50,27 m²
187879 | Picea abies | STR01.187879 | 209 | 19,63 m²
187880 | Acer platanoides | STR01.187880 | 196 | 38,48 m²
187881 | Salix caprea | STR01.187881 | 188 | 28,27 m²
187903 | Betula pendula | STR01.187903 | 145 | 50,27 m²
187908 | Betula pendula | STR01.187908 | 136 | 78,54 m²
187909 | Populus tremula | STR01.187909 | 134 | 63,62 m²
187910 | Populus tremula | STR01.187910 | 132 | 28,27 m²
187911 | Betula pendula | STR01.187911 | 131 | 38,48 m²
187912 | Betula pendula | STR01.187912 | 130 | 28,27 m²
187913 | Picea abies | STR01.187913 | 120 | 78,54 m²
187914 | Zapojený porost | STR01.187914 | 119 | 95,03 m²
187944 | Acer platanoides | STR01.187944 | 50 | 38,48 m²
187945 | suchý strom | STR01.187945 | 47 | 78,54 m²
187946 | Acer pseudoplatanus | STR01.187946 | 46 | 113,10 m²
187947 | Salix caprea | STR01.187947 | 43 | 113,10 m²
187948 | Salix caprea | STR01.187948 | 41 | 78,54 m²
187949 | Salix caprea | STR01.187949 | 39 | 113,10 m²
187950 | Larix decidua | STR01.187950 | 37 | 50,27 m²
187951 | Larix decidua | STR01.187951 | 33 | 19,63 m²
187952 | Larix decidua | STR01.187952 | 32 | 19,63 m²
187953 | Quercus rubra | STR01.187953 | 29 | 19,63 m²
187954 | Populus tremula | STR01.187954 | 28 | 12,57 m²
187955 | padlá souš | STR01.187955 | 26 | 113,10 m²
187956 | Prunus cerasifera | STR01.187956 | 23 | 7,07 m²
187957 | Tilia platyphyllos | STR01.187957 | 22 | 50,27 m²
187958 | Prunus cerasifera | STR01.187958 | 21 | 78,54 m²
187959 | Acer pseudoplatanus | STR01.187959 | 20 | 7,07 m²
187960 | Salix caprea | STR01.187960 | 19 | 12,57 m²
187961 | Salix caprea | STR01.187961 | 18 | 50,27 m²
187962 | Betula pendula | STR01.187962 | 17 | 7,07 m²
187963 | Betula pendula | STR01.187963 | 16 | 28,27 m²
187964 | Betula pendula | STR01.187964 | 15 | 7,07 m²
187965 | Salix caprea | STR01.187965 | 13 | 19,63 m²
187966 | Salix caprea | STR01.187966 | 12 | 19,63 m²
187967 | Betula pendula | STR01.187967 | 1 | 38,48 m²
187968 | Salix caprea | STR01.187968 | 123 | 28,27 m²
187979 | Betula pendula | STR01.187979 | 218 | 50,27 m²
187980 | Betula pendula | STR01.187980 | 217 | 78,54 m²
187981 | Betula pendula | STR01.187981 | 216 | 28,27 m²
187982 | Acer platanoides | STR01.187982 | 213 | 38,48 m²
187983 | Populus tremula | STR01.187983 | 212 | 28,27 m²
187984 | torzo stromu | STR01.187984 | 211 | 50,27 m²
187985 | Populus tremula | STR01.187985 | 210 | 28,27 m²
187986 | Betula pendula | STR01.187986 | 208 | 78,54 m²
187987 | torzo stromu | STR01.187987 | 207 | 19,63 m²
187988 | Betula pendula | STR01.187988 | 206 | 12,57 m²
187989 | Betula pendula | STR01.187989 | 205 | 63,62 m²
187990 | Populus tremula | STR01.187990 | 204 | 19,63 m²
187991 | Betula pendula | STR01.187991 | 203 | 19,63 m²
187992 | Betula pendula | STR01.187992 | 202 | 50,27 m²
187993 | Betula pendula | STR01.187993 | 201 | 63,62 m²
187994 | Betula pendula | STR01.187994 | 200 | 19,63 m²
187995 | Betula pendula | STR01.187995 | 199 | 28,27 m²
187996 | Betula pendula | STR01.187996 | 198 | 7,07 m²
187997 | Acer pseudoplatanus | STR01.187997 | 197 | 7,07 m²
187998 | Acer pseudoplatanus | STR01.187998 | 195 | 28,27 m²
187999 | Acer platanoides | STR01.187999 | 194 | 38,48 m²
188000 | Salix caprea | STR01.188000 | 193 | 28,27 m²
188001 | Salix caprea | STR01.188001 | 192 | 113,10 m²
188002 | Betula pendula | STR01.188002 | 191 | 78,54 m²
188003 | Betula pendula | STR01.188003 | 190 | 78,54 m²
188004 | Betula pendula | STR01.188004 | 189 | 113,10 m²
188005 | Betula pendula Salix caprea | STR01.188005 | 187 | 38,48 m²
188023 | Salix caprea | STR01.188023 | 129 | 7,07 m²
188024 | Salix caprea | STR01.188024 | 128 | 12,57 m²
188025 | Picea abies | STR01.188025 | 127 | 7,07 m²
188026 | Salix caprea | STR01.188026 | 126 | 12,57 m²
188027 | Acer pseudoplatanus | STR01.188027 | 125 | 12,57 m²
188028 | Acer pseudoplatanus cv. | STR01.188028 | 122 | 78,54 m²
188029 | Salix caprea | STR01.188029 | 118 | 19,63 m²
188049 | Alnus glutinosa | STR01.188049 | 48 | 28,27 m²
188050 | Populus tremula | STR01.188050 | 49 | 12,57 m²
188051 | Acer platanoides | STR01.188051 | 45 | 19,63 m²
188052 | Populus tremula | STR01.188052 | 44 | 28,27 m²
188053 | Populus tremula | STR01.188053 | 42 | 12,57 m²
188054 | Populus tremula | STR01.188054 | 40 | 7,07 m²
188055 | Populus tremula | STR01.188055 | 38 | 12,57 m²
188056 | Betula pendula | STR01.188056 | 36 | 7,07 m²
188057 | Populus tremula | STR01.188057 | 35 | 19,63 m²
188058 | Populus tremula | STR01.188058 | 34 | 28,27 m²
188059 | Quercus robur | STR01.188059 | 31 | 78,54 m²
188060 | Populus tremula | STR01.188060 | 30 | 28,27 m²
188061 | Populus tremula | STR01.188061 | 27 | 28,27 m²
188062 | Populus tremula | STR01.188062 | 25 | 12,57 m²
188063 | Populus tremula | STR01.188063 | 24 | 28,27 m²
188064 | Populus tremula | STR01.188064 | 14 | 50,27 m²
188065 | Populus tremula | STR01.188065 | 11 | 50,27 m²
188066 | Populus tremula | STR01.188066 | 10 | 63,62 m²
188067 | Populus tremula | STR01.188067 | 9 | 78,54 m²
188068 | Populus tremula | STR01.188068 | 8 | 28,27 m²
188069 | Populus tremula | STR01.188069 | 7 | 38,48 m²
188070 | Populus tremula | STR01.188070 | 5 | 19,63 m²
188071 | Populus tremula | STR01.188071 | 6 | 28,27 m²
188072 | Betula pendula | STR01.188072 | 4 | 19,63 m²
188073 | Betula pendula | STR01.188073 | 3 | 50,27 m²
188074 | Populus tremula | STR01.188074 | 2 | 28,27 m²
188081 | Populus tremula | STR01.188081 | 137 | 7,07 m²
188082 | Quercus robur | STR01.188082 | 133 | 7,07 m²

# IfcGeographicElement: #Strom:#Strom (132)
In: 1NP
Type - Material: #Strom
Type - CZ_DTcommon - DT_name: výsadba rostlin, stromů a keřů
Type - CZ_ElementCommon - ElementProjectSpecificName: #Strom; ElementProjectSpecificDescription: Stávající zeleň; ElementProjectSpecificIdentifier: STR02
Type - CZ_CCI - CCI_FunctionalSystemsCode: A; CCI_TechnicalSystemsCode: RA; CCI_ComponentsCode: TRA
CZ_ElementCommon - ElementProjectObjectIdentifier: IO 800; StoreyProjectSpecificIdentifier: 1NP; sets with these values: 2
Qto_BuildingBaseQuantities - sets with these values: 2
Name (#Strom:#Strom:...) | Pset_SiteCommon, Reference | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | NetFloorArea
187864 | Prunus avium | STR02.187864 | 241 | 95,03 m²
187865 | Populus tremula | STR02.187865 | 240 | 78,54 m²
187867 | Populus tremula | STR02.187867 | 239 | 78,54 m²
187868 | Populus tremula | STR02.187868 | 238 | 28,27 m²
187869 | Populus tremula | STR02.187869 | 237 | 19,63 m²
187870 | Populus tremula | STR02.187870 | 236 | 38,48 m²
187871 | Populus tremula | STR02.187871 | 234 | 7,07 m²
187872 | Populus tremula | STR02.187872 | 233 | 7,07 m²
187873 | Populus tremula | STR02.187873 | 232 | 12,57 m²
187874 | Populus tremula | STR02.187874 | 229 | 28,27 m²
187875 | Populus tremula | STR02.187875 | 225 | 78,54 m²
187876 | Populus tremula | STR02.187876 | 219 | 78,54 m²
187882 | Picea abies | STR02.187882 | 186 | 12,57 m²
187883 | Picea abies | STR02.187883 | 185 | 28,27 m²
187884 | Populus tremula | STR02.187884 | 184 | 38,48 m²
187885 | Populus tremula | STR02.187885 | 183 | 95,03 m²
187886 | Populus tremula | STR02.187886 | 182 | 38,48 m²
187887 | Betula pendula | STR02.187887 | 181 | 19,63 m²
187888 | Larix decidua | STR02.187888 | 180 | 78,54 m²
187889 | Populus tremula | STR02.187889 | 175 | 50,27 m²
187890 | Betula pendula | STR02.187890 | 177 | 28,27 m²
187891 | Picea abies | STR02.187891 | 176 | 78,54 m²
187892 | Populus tremula | STR02.187892 | 172 | 28,27 m²
187893 | Betula pendula | STR02.187893 | 171 | 38,48 m²
187894 | Acer platanoides | STR02.187894 | 167 | 95,03 m²
187895 | Betula pendula | STR02.187895 | 165 | 19,63 m²
187896 | Betula pendula | STR02.187896 | 164 | 28,27 m²
187898 | Betula pendula | STR02.187898 | 155 | 113,10 m²
187899 | Salix caprea | STR02.187899 | 154 | 113,10 m²
187900 | Betula pendula | STR02.187900 | 148 | 78,54 m²
187901 | Betula pendula | STR02.187901 | 147 | 113,10 m²
187902 | Populus tremula | STR02.187902 | 146 | 113,10 m²
187904 | Betula pendula | STR02.187904 | 143 | 50,27 m²
187905 | Betula pendula | STR02.187905 | 141 | 38,48 m²
187906 | Populus tremula | STR02.187906 | 140 | 38,48 m²
187907 | Betula pendula | STR02.187907 | 139 | 78,54 m²
187915 | Picea abies | STR02.187915 | 116 | 63,62 m²
187916 | Prunus cerasifera | STR02.187916 | 112 | 78,54 m²
187917 | Betula pendula | STR02.187917 | 111 | 78,54 m²
187918 | Pinus strobus | STR02.187918 | 104 | 78,54 m²
187919 | Pinus strobus | STR02.187919 | 101 | 113,10 m²
187920 | Larix decidua | STR02.187920 | 100 | 78,54 m²
187921 | torzo listnatého stromu | STR02.187921 | 99 | 113,10 m²
187922 | Populus tremula | STR02.187922 | 96 | 50,27 m²
187923 | Larix decidua | STR02.187923 | 94 | 78,54 m²
187924 | Larix decidua | STR02.187924 | 91 | 28,27 m²
187925 | Salix caprea | STR02.187925 | 90 | 38,48 m²
187926 | Salix caprea | STR02.187926 | 89 | 28,27 m²
187927 | Salix caprea | STR02.187927 | 88 | 38,48 m²
187928 | Pseudotsuga menziesii | STR02.187928 | 83 | 19,63 m²
187929 | Pseudotsuga menziesii | STR02.187929 | 81 | 113,10 m²
187930 | Pseudotsuga menziesii | STR02.187930 | 79 | 50,27 m²
187931 | Populus tremula | STR02.187931 | 76 | 50,27 m²
187932 | Pseudotsuga menziesii | STR02.187932 | 75 | 50,27 m²
187933 | Zapojený porost | STR02.187933 | 74 | 28,27 m²
187934 | Pseudotsuga menziesii | STR02.187934 | 73 | 50,27 m²
187935 | torzo Pseudotsuga menziesii | STR02.187935 | 71 | 19,63 m²
187936 | Pseudotsuga menziesii | STR02.187936 | 68 | 50,27 m²
187937 | Pseudotsuga menziesii | STR02.187937 | 66 | 78,54 m²
187938 | Pseudotsuga menziesii | STR02.187938 | 65 | 38,48 m²
187939 | Pseudotsuga menziesii | STR02.187939 | 61 | 38,48 m²
187940 | Larix decidua | STR02.187940 | 59 | 78,54 m²
187941 | Salix caprea | STR02.187941 | 57 | 28,27 m²
187942 | Pseudotsuga menziesii | STR02.187942 | 54 | 176,71 m²
187943 | Larix decidua | STR02.187943 | 52 | 28,27 m²
187969 | Salix caprea | STR02.187969 | 235 | 12,57 m²
187970 | Salix caprea | STR02.187970 | 231 | 28,27 m²
187971 | Betula pendula | STR02.187971 | 230 | 50,27 m²
187972 | torzo stromu | STR02.187972 | 228 | 95,03 m²
187973 | Betula pendula | STR02.187973 | 227 | 78,54 m²
187974 | Betula pendula | STR02.187974 | 226 | 19,63 m²
187975 | Betula pendula | STR02.187975 | 224 | 38,48 m²
187976 | torzo Prunus cerasifera | STR02.187976 | 223 | 63,62 m²
187977 | Salix caprea | STR02.187977 | 221 | 95,03 m²
187978 | Salix caprea | STR02.187978 | 220 | 38,48 m²
188006 | Betula pendula | STR02.188006 | 174 | 50,27 m²
188007 | Betula pendula Acer platanoides | STR02.188007 | 173 | 38,48 m²
188008 | Acer platanoides | STR02.188008 | 170 | 12,57 m²
188009 | Acer platanoides | STR02.188009 | 169 | 38,48 m²
188010 | Acer platanoides | STR02.188010 | 168 | 28,27 m²
188011 | Acer platanoides | STR02.188011 | 163 | 50,27 m²
188012 | Acer platanoides | STR02.188012 | 161 | 113,10 m²
188013 | Populus tremula | STR02.188013 | 158 | 113,10 m²
188014 | Populus tremula | STR02.188014 | 157 | 113,10 m²
188015 | Acer platanoides | STR02.188015 | 156 | 19,63 m²
188016 | Populus tremula | STR02.188016 | 153 | 50,27 m²
188017 | Acer platanoides | STR02.188017 | 152 | 78,54 m²
188018 | Alnus glutinosa | STR02.188018 | 151 | 19,63 m²
188019 | Alnus glutinosa | STR02.188019 | 150 | 28,27 m²
188020 | Salix caprea | STR02.188020 | 149 | 28,27 m²
188021 | Salix caprea | STR02.188021 | 144 | 50,27 m²
188022 | Salix caprea | STR02.188022 | 142 | 153,94 m²
188030 | Alnus glutinosa | STR02.188030 | 117 | 50,27 m²
188031 | Salix caprea | STR02.188031 | 108 | 38,48 m²
188032 | Salix caprea | STR02.188032 | 107 | 38,48 m²
188033 | Salix caprea | STR02.188033 | 106 | 38,48 m²
188034 | Prunus avium | STR02.188034 | 97 | 176,71 m²
188035 | Acer pseudoplatanus | STR02.188035 | 87 | 7,07 m²
188036 | Salix caprea | STR02.188036 | 86 | 78,54 m²
188037 | Salix caprea | STR02.188037 | 85 | 201,06 m²
188038 | Acer pseudoplatanus | STR02.188038 | 84 | 50,27 m²
188039 | Alnus glutinosa | STR02.188039 | 78 | 28,27 m²
188040 | Fraxinus excelsior | STR02.188040 | 77 | 19,63 m²
188041 | Salix caprea | STR02.188041 | 69 | 19,63 m²
188042 | zlomené torzo | STR02.188042 | 67 | 12,57 m²
188043 | Betula pendula | STR02.188043 | 64 | 113,10 m²
188044 | Alnus glutinosa | STR02.188044 | 63 | 78,54 m²
188045 | Alnus glutinosa | STR02.188045 | 62 | 50,27 m²
188046 | Populus tremula | STR02.188046 | 60 | 7,07 m²
188047 | Acer pseudoplatanus | STR02.188047 | 56 | 19,63 m²
188048 | Alnus glutinosa | STR02.188048 | 55 | 28,27 m²
188075 | Populus tremula | STR02.188075 | 222 | 28,27 m²
188076 | Populus tremula | STR02.188076 | 178 | 12,57 m²
188077 | Acer platanoides | STR02.188077 | 166 | 78,54 m²
188078 | Acer platanoides | STR02.188078 | 160 | 28,27 m²
188079 | Crataegus monogyna | STR02.188079 | 159 | 78,54 m²
188080 | Populus tremula | STR02.188080 | 138 | 113,10 m²
188083 | Populus tremula | STR02.188083 | 115 | 95,03 m²
188084 | Populus tremula | STR02.188084 | 114 | 113,10 m²
188085 | Populus tremula | STR02.188085 | 113 | 7,07 m²
188086 | Populus tremula | STR02.188086 | 110 | 12,57 m²
188087 | Populus tremula | STR02.188087 | 105 | 12,57 m²
188088 | Acer platanoides | STR02.188088 | 103 | 12,57 m²
188089 | Populus tremula | STR02.188089 | 102 | 63,62 m²
188090 | Populus tremula | STR02.188090 | 98 | 78,54 m²
188091 | Populus tremula | STR02.188091 | 95 | 78,54 m²
188092 | Alnus glutinosa | STR02.188092 | 93 | 113,10 m²
188093 | Betula pendula | STR02.188093 | 92 | 19,63 m²
188094 | Betula pendula | STR02.188094 | 82 | 28,27 m²
188095 | Alnus glutinosa | STR02.188095 | 80 | 3,14 m²
188096 | Betula pendula | STR02.188096 | 72 | 7,07 m²
188097 | Alnus glutinosa | STR02.188097 | 53 | 12,57 m²

# IfcGeographicElement: #Strom:Nový (14)
In: 1NP
Type - Material: #Strom
Type - CZ_DTcommon - DT_name: výsadba rostlin, stromů a keřů
Type - CZ_ElementCommon - ElementProjectSpecificName: Nový; ElementProjectSpecificDescription: Nová zeleň; ElementProjectSpecificIdentifier: STR03
Type - CZ_CCI - CCI_FunctionalSystemsCode: A; CCI_TechnicalSystemsCode: RA; CCI_ComponentsCode: TRA
CZ_ElementCommon - ElementProjectObjectIdentifier: IO 800; StoreyProjectSpecificIdentifier: 1NP; sets with these values: 2
Qto_BuildingBaseQuantities - NetFloorArea: 50,27 m²; sets with these values: 2
Name (#Strom:Nový:...) | Pset_SiteCommon, Reference | CZ_ElementCommon, Reference
237262 | Acer plataniodes | STR03.237262
237297 | acer campestre "green column" | STR03.237297
237310 | acer campestre "green column" | STR03.237310
237333 | acer campestre "green column" | STR03.237333
237366 | Acer campestre | STR03.237366
237373 | Acer campestre | STR03.237373
237388 | quercus patraea, novy | STR03.237388
237432 | Acer campestre | STR03.237432
237449 | quercus patraea, novy | STR03.237449
237466 | quercus patraea, novy | STR03.237466
237500 | quercus patraea, novy | STR03.237500
237536 | acer campestre "elegant" | STR03.237536
237566 | acer campestre "elegant" | STR03.237566
237575 | acer campestre "elegant" | STR03.237575
