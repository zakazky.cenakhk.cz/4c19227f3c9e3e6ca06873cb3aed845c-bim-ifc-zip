Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement []
File name: Y:\02_zakazky\A-22-1042_Parkovaci dum Trutnov\15_CD\2025-02-02_CD_A-22-1042_Parkovaci dum Trutnov_DPS\model\ifc\SO01-SLP.ifc
Time: 2025-03-07T20:06:36+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativní uživatelské rozhraní 20.2.12.1

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 439500 mm

# IfcBuildingStorey: Podlaží:#Hlavní, 1.S
LongName: 1.S; Elevation: 0 mm

# IfcBuildingElementProxy: CCTV-Kamera:CCTV-Kamera (4)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CCTV-Kamera; ElementProjectSpecificDescription: venkovní kamera; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kamera
Type - CZ_CCI - CCI_FunctionalSystemsCode: M; CCI_TechnicalSystemsCode: LF; CCI_ComponentsCode: BXC
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (CCTV-Kamera:CCTV-Kamera:...) | Reference | ElementProjectSpecificIdentifier
1770597 | kamera exteriér.1770597 | 2
1771014 | kamera exteriér.1771014 | 3
1946213 | kamera exteriér.1946213 | 43
1946373 | kamera exteriér.1946373 | 44

# IfcBuildingElementProxy: Domovní interkom:Intercom, Domovní interkom:Intercom:1772723
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Intercom; ElementProjectSpecificDescription: interkomová vstupní jednotka
CZ_ElementCommon - ElementProjectSpecificIdentifier: 5

# IfcBuildingElementProxy: EZS - Pohybový detektor PIR:EZS - Pohybový detektor PIR (4)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: EZS - Pohybový detektor PIR; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Infrapasivní detektor pohybu
Type - CZ_DTcommon - DT_name: detektor
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LE; CCI_ComponentsCode: KED
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (EZS - Pohybový detektor PIR:EZS - Pohybový detektor PIR:...) | Reference | ElementProjectSpecificIdentifier
1790232 | PIR.1790232 | 30
1791396 | PIR.1791396 | 32
1791427 | PIR.1791427 | 33
1948522 | PIR.1948522 | 45

# IfcBuildingElementProxy: EZS-Klávesnice:EZS-Klávesnice, EZS-Klávesnice:EZS-Klávesnice:1957133
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: EZS-Klávesnice; ElementProjectSpecificDescription: Klávesnice EZS
CZ_ElementCommon - ElementProjectSpecificIdentifier: KL10

# IfcBuildingElementProxy: Ústředna EZS:Ústředna EZS, Ústředna EZS:Ústředna EZS:1773943
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Ústředna EZS; ElementProjectObjectIdentifier: so01; ElementProjectSpecificDescription: ústředna PZTS
Type - CZ_DTcommon - DT_name: ústředna EZS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LE; CCI_ComponentsCode: KED
CZ_ElementCommon - Reference: Digiplex.1773943; ElementProjectSpecificIdentifier: 6; StoreyProjectSpecificIdentifier: 1.S

# IfcDistributionPort, Port_1773943
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: DATA

# IfcElectricAppliance: Data 2xRJ45:Data 2xRJ45 (12)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Data 2xRJ45; ElementProjectSpecificDescription: Datová zásuvka 2x RJ45
Name (Data 2xRJ45:Data 2xRJ45:...) | ElementProjectSpecificIdentifier
1805132 | 3
1805274 | 4
1805669 | 5
1806445 | 6
1806804 | 7
1806962 | 8
1807875 | 9
1952741 | 10
1953589 | 11
1954097 | 12
1954344 | 13
1954520 | 14

# IfcElectricAppliance: datový rack 800x800:45U, datový rack 800x800:45U:1767891
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 45U; ElementProjectSpecificDescription: Datový rozvaděč SK; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče (RACK) ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: RACK - SK.1767891; ElementProjectSpecificIdentifier: 2; StoreyProjectSpecificIdentifier: 1.S
