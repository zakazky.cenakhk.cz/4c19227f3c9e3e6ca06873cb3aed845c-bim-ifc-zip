Properties of the parts of a building model (IFC4), part 2 of 3

# IfcDistributionPort (1062)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_3338609_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363797_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3338632_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3338924_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3338632_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3338634_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3338657_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3338634_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3339844_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 3
Port_3339844_3 | SOURCEANDSINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 3
Port_3340197_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 8
Port_3340197_3 | SOURCEANDSINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 8
InPort_3345084_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3345034_3 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3345933_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3345827_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3345995_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3345851_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3365090_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3345933_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3365061_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3345995_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3346348_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3346299_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3346413_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3346321_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3370099_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3346348_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3369405_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3346413_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3346734_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3346697_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3346762_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3346716_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3346736_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3346734_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372747_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3346736_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372630_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3346762_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3349812_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349475_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349475_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349607_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349503_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3350114_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349956_3 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349503_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349814_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349812_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349981_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349983_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3350116_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349981_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3350114_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3350116_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3354373_3 | SINK | DUCT | VENTILATION | EF.G
OutPort_3354316_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3354316_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3354464_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3354362_0 | SINK | DUCT | VENTILATION | EF.G
OutPort_3354373_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3363944_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3354362_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3354464_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3354951_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3354951_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3355044_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3355044_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3355210_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3355340_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355262_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355298_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355340_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355459_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355298_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355450_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355573_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355824_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355450_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355677_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355459_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355573_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355677_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355824_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357993_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358318_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3355824_3 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357181_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357256_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358368_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357181_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358367_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357191_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357191_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358368_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357256_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357264_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357264_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358330_3 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357877_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358018_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357913_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357877_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358003_3 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3357913_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3357993_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358003_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358018_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358027_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358330_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358318_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358789_3 | SINK | DUCT | VENTILATION | EF.H
OutPort_3358637_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3358637_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359239_4 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359239_3 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359212_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359212_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359414_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359239_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359494_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360946_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359402_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359414_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360964_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359494_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359530_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359645_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359664_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360015_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360031_3 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360031_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360025_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360025_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360117_3 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360117_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360107_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360107_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360138_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360448_3 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360398_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360398_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360490_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360448_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360449_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360964_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360946_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3361351_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3361384_2 | SOURCE | DUCT | VENTILATION | EF.T
Port_3361627_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3362995_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3361627_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3361643_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3361637_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3361643_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3361637_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3361668_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3363004_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3361668_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3361682_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3361676_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3361682_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3361676_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3362975_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3362977_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3362975_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3362979_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3362984_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3362986_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3362984_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3362988_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3362993_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3362995_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3362993_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3362997_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3363002_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3363004_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3363002_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3363006_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3363026_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363269_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363026_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363030_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363258_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363030_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363034_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 1
Port_3363034_3 | SOURCEANDSINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 1
Port_3363256_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363258_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363256_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363260_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363265_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363267_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363265_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363269_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363377_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363823_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363377_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363480_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363844_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363480_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363512_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363853_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363512_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363556_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363862_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363556_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363651_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363659_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363651_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363860_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363675_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363683_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363675_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363851_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363753_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363761_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363753_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363842_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363789_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363797_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363789_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363821_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363819_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363821_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363819_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363823_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3363840_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363842_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363840_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363844_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363849_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363851_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363849_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363853_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363858_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363860_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363858_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363862_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
InPort_3363942_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3363935_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3363935_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3363944_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364135_0 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364281_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364283_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364135_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364281_3 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364145_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364145_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364323_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364323_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364836_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364836_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364895_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3364895_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3365061_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3365140_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365090_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3365302_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365140_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3365314_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365302_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3365309_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365314_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3365533_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365309_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3365974_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365533_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3366001_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3365974_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3366241_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3366001_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3366001_3 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367380_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367054_3 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3366241_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3366653_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3366383_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3366383_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367846_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3366581_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367845_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367846_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3366581_1 | SOURCE | DUCT | VENTILATION | EF.G3
Port_3366653_2 | SOURCEANDSINK | DUCT | VENTILATION | EF.G3
Port_3367425_1 | SOURCEANDSINK | DUCT | VENTILATION | EF.G3
Port_3366773_1 | SOURCEANDSINK | DUCT | VENTILATION | EF.G3
Port_3367757_0 | SOURCEANDSINK | DUCT | VENTILATION | EF.G3
Port_3366773_2 | SOURCEANDSINK | DUCT | VENTILATION | EF.G3
Port_3367047_1 | SOURCEANDSINK | DUCT | VENTILATION | EF.G3
InPort_3367047_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367054_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367380_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367430_3 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367430_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367425_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367425_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3366653_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367757_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3366773_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367766_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367757_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3369565_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369284_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3369284_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3370060_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3369349_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369340_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3369340_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369351_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3369351_3 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369716_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3370060_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369405_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3369716_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369565_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3370169_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370099_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370483_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370169_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370496_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370483_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370727_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370496_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370900_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370659_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370659_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370727_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370932_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370900_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371132_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3370932_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3370932_3 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372060_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371961_3 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371132_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371607_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371198_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371198_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372165_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372220_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371297_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371297_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371954_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371654_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371607_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372067_3 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371654_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3371954_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3371961_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372060_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372067_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372095_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372164_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372165_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372095_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372302_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372220_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372429_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372426_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372426_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372431_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372430_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372429_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372570_3 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372430_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372431_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372630_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372437_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372435_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372435_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372436_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372436_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372749_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372438_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372437_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372439_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372438_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372438_3 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372446_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372445_3 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372439_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372442_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372440_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372440_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3373193_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3373372_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372441_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372441_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372444_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372443_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372442_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372447_3 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372443_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372444_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372445_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372446_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372447_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372569_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372562_0 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372562_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372570_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3372740_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372747_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3372749_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3372740_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3373050_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3373192_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3373193_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3373050_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3373377_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3373372_1 | SOURCE | DUCT | VENTILATION | EF.G1
OutPort_3374448_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
InPort_3374448_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
OutPort_3374462_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
InPort_3374462_3 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
OutPort_3374456_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
InPort_3374456_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
OutPort_3374485_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
InPort_3374485_3 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
OutPort_3374468_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
InPort_3374468_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
OutPort_3374549_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 4
OutPort_3374746_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
InPort_3374746_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
OutPort_3374750_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
InPort_3374750_3 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
OutPort_3374748_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
InPort_3374748_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
OutPort_3374754_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
InPort_3374754_3 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
OutPort_3374752_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
InPort_3374752_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
OutPort_3374756_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 5
Port_3382861_2 | SOURCEANDSINK | DUCT
Port_3382861_3 | SOURCEANDSINK | DUCT
InPort_3385872_0 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3397186_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3396766_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3385872_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3389307_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3389327_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3389327_3 | SINK | DUCT | VENTILATION | EF.H
OutPort_3389319_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3389319_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3389348_1 | SOURCE | DUCT | VENTILATION | EF.H
Port_3392874_1 | SOURCEANDSINK | PIPE | HEATING
Port_3392874_2 | SOURCEANDSINK | PIPE | HEATING
Port_3395264_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3397517_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3395264_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3397519_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3395279_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3397517_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3395279_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3395352_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3397519_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3395352_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 11
Port_3395387_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3397538_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3395387_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3397540_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3395391_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3397538_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3395391_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3395395_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3397540_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
Port_3395395_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 12
InPort_3395688_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3395989_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3396053_0 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3395688_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3395971_2 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3395816_0 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3395816_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3396190_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3395888_0 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3396266_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3397186_3 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3395888_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3395989_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3395971_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3396036_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3396053_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3396268_0 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3396036_2 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
InPort_3396266_1 | SINK | DUCT | VENTILATION | Mechanické Odvod vzduchu 6
OutPort_3396268_1 | SOURCE | DUCT | VENTILATION | Mechanické Odvod vzduchu 6

# IfcDistributionSystem: Cu potrubí - plyn (12)
PredefinedType: HEATING
Name
Cu potrubí - plyn 1
Cu potrubí - plyn 2
Cu potrubí - plyn 3
Cu potrubí - plyn 4
Cu potrubí - plyn 5
Cu potrubí - plyn 6
Cu potrubí - plyn 7
Cu potrubí - plyn 8
Cu potrubí - plyn 9
Cu potrubí - plyn 10
Cu potrubí - plyn 11
Cu potrubí - plyn 12

# IfcDistributionSystem: Odvod vzduchu (13)
PredefinedType: VENTILATION
Name
EF.T
EF.H
EF.G2
EF.G3
EF.G4
EF.G1
EF.G
Mechanické Odvod vzduchu 3
Mechanické Odvod vzduchu 8
Mechanické Odvod vzduchu 1
Mechanické Odvod vzduchu 4
Mechanické Odvod vzduchu 5
Mechanické Odvod vzduchu 6

# IfcDistributionSystem: Přívod vzduchu (4)
PredefinedType: VENTILATION
Name
Mechanické Přívod vzduchu 2
Mechanické Přívod vzduchu 1
Mechanické Přívod vzduchu 3
Mechanické Přívod vzduchu 4

# IfcDistributionSystem: Čerstvý vzduch, SF.CH
PredefinedType: VENTILATION

# IfcDuctFitting: AZK NCH Nastavec ctyrhranny:Standardní (9)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka - Nástavec čtyřhranný. Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectObjectIdentifier: SO01
Name (AZK NCH Nastavec ctyrhranny:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3243414 | STŘECHA | TA02.81.533 | STŘECHA | SF.CH
3243480 | STŘECHA | TA02.81.534 | STŘECHA | SF.CH
3243549 | STŘECHA | TA02.81.535 | STŘECHA | SF.CH
3243629 | STŘECHA | TA02.81.536 | STŘECHA | SF.CH
3335081 | 1.S | TA02.81.537 | 1.S | EF.G
3348524 | STŘECHA | TA02.81.538 | STŘECHA | SF.CH
3364283 | 1.NP | TA02.81.539 | 1.NP | EF.G
3369349 | 2.NP | TA02.81.540 | 2.NP | EF.G
3372569 | 3.NP | TA02.81.541 | 3.NP | EF.G

# IfcDuctFitting: AZK OBJ Odbocka kruhova:AZK OBJ Odbocka kruhova (6)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka potrubí - odbočka kruhová. Kruhové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakost DX 51 D+Z 200 MAC.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK OBJ Odbocka kruhova; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Name (AZK OBJ Odbocka kruhova:AZK OBJ Odbocka kruhova:...) | Reference | Group
3252786 | TA02.81.25 | EF.H
3313930 | TA02.81.26 | EF.T
3313934 | TA02.81.27 | EF.T
3314258 | TA02.81.28 | EF.T
3359239 | TA02.81.29 | EF.H
3360448 | TA02.81.30 | EF.H

# IfcDuctFitting: AZK OCS Odbocka ctyrhranna universal:AZK OCS Odbocka ctyrhranna rovna (4)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka potrubí - odbočka čtyřhranná. Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.Přírubové profily jsou k potrubí upevněny vzájemným prolisováním nebo mohou být dle požadavku sbodovány. Rohové oblasti jsou utěsněny polyuretanovým tmelem.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK OCS Odbocka ctyrhranna rovna; ElementProjectObjectIdentifier: SO01
Name (AZK OCS Odbocka ctyrhranna universal:AZK OCS Odbocka ctyrhranna rovna:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3355824 | 1.S | TA02.81.31 | 1.S | EF.G2
3366001 | 1.NP | TA02.81.32 | 1.NP | EF.G3
3370932 | 2.NP | TA02.81.33 | 2.NP | EF.G4
3372438 | 3.NP | TA02.81.34 | 3.NP | EF.G1

# IfcDuctFitting: AZK OL_OLP Oblouk ctyrhranny:AZK OLP OL Oblouk ctyrhranny (53)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka potrubí - oblouk čtyřhranný. Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.Přírubové profily jsou k potrubí upevněny vzájemným prolisováním nebo mohou být dle požadavku sbodovány. Rohové oblasti jsou utěsněny polyuretanovým tmelem.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK OLP OL Oblouk ctyrhranny; ElementProjectObjectIdentifier: SO01
Name (AZK OL_OLP Oblouk ctyrhranny:AZK OLP OL Oblouk ctyrhranny:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3242625 | STŘECHA | TA02.81.35 | STŘECHA | SF.CH
3243086 | STŘECHA | TA02.81.36 | STŘECHA | SF.CH
3255033 | 1.NP | TA02.81.37 | 1.NP | EF.G3
3255034 | 1.NP | TA02.81.38 | 1.NP | EF.G3
3255036 | 1.NP | TA02.81.39 | 1.NP | EF.G3
3255055 | 2.NP | TA02.81.40 | 2.NP | EF.G4
3255121 | 3.NP | TA02.81.41 | 3.NP | EF.G1
3268623 | 1.S | TA02.81.42 | 1.S | EF.G2
3275021 | 1.S | TA02.81.43 | 1.S | EF.G2
3275028 | 1.S | TA02.81.44 | 1.S | EF.G2
3275134 | 1.S | TA02.81.45 | 1.S | EF.G2
3276166 | 1.S | TA02.81.46 | 1.S | EF.G2
3276203 | 1.S | TA02.81.47 | 1.S | EF.G2
3276309 | 1.S | TA02.81.48 | 1.S | EF.G2
3277428 | 1.S | TA02.81.49 | 1.S | EF.G2
3278318 | 1.S | TA02.81.50 | 1.S | EF.G2
3280405 | 1.NP | TA02.81.51 | 1.NP | EF.G3
3280412 | 1.NP | TA02.81.52 | 1.NP | EF.G3
3280445 | 1.NP | TA02.81.53 | 1.NP | EF.G3
3280469 | 1.NP | TA02.81.54 | 1.NP | EF.G3
3280563 | 1.NP | TA02.81.55 | 1.NP | EF.G3
3281615 | 1.NP | TA02.81.56 | 1.NP | EF.G3
3283943 | 2.NP | TA02.81.57 | 2.NP | EF.G4
3283945 | 2.NP | TA02.81.58 | 2.NP | EF.G4
3283976 | 2.NP | TA02.81.59 | 2.NP | EF.G4
3284013 | 2.NP | TA02.81.60 | 2.NP | EF.G4
3284041 | 2.NP | TA02.81.61 | 2.NP | EF.G4
3284050 | 2.NP | TA02.81.62 | 2.NP | EF.G4
3285024 | 2.NP | TA02.81.63 | 2.NP | EF.G4
3286531 | 3.NP | TA02.81.64 | 3.NP | EF.G1
3286533 | 3.NP | TA02.81.65 | 3.NP | EF.G1
3286534 | 3.NP | TA02.81.66 | 3.NP | EF.G1
3286602 | 3.NP | TA02.81.67 | 3.NP | EF.G1
3286609 | 3.NP | TA02.81.68 | 3.NP | EF.G1
3287580 | 3.NP | TA02.81.69 | 3.NP | EF.G1
3287581 | 3.NP | TA02.81.70 | 3.NP | EF.G1
3355459 | 1.S | TA02.81.71 | 1.S | EF.G2
3358027 | 1.S | TA02.81.72 | 1.S | EF.G2
3358367 | 1.S | TA02.81.73 | 1.S | EF.G2
3358368 | 1.S | TA02.81.74 | 1.S | EF.G2
3363944 | 1.S | TA02.81.75 | 1.S | EF.G
3365314 | 1.NP | TA02.81.76 | 1.NP | EF.G3
3367766 | 1.NP | TA02.81.77 | 1.NP | EF.G3
3367845 | 1.NP | TA02.81.78 | 1.NP | EF.G3
3367846 | 1.NP | TA02.81.79 | 1.NP | EF.G3
3370496 | 2.NP | TA02.81.80 | 2.NP | EF.G4
3372164 | 2.NP | TA02.81.81 | 2.NP | EF.G4
3372165 | 2.NP | TA02.81.82 | 2.NP | EF.G4
3372302 | 2.NP | TA02.81.83 | 2.NP | EF.G4
3372749 | 3.NP | TA02.81.84 | 3.NP | EF.G1
3373192 | 3.NP | TA02.81.85 | 3.NP | EF.G1
3373193 | 3.NP | TA02.81.86 | 3.NP | EF.G1
3373377 | 3.NP | TA02.81.87 | 3.NP | EF.G1

# IfcDuctFitting: AZK OS OLL Oblouk kruhovy:AZK OS OLL Oblouk kruhovy (12)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka potrubí - oblouk kruhový. Kruhové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakost DX 51 D+Z 200 MAC.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK OS OLL Oblouk kruhovy; ElementProjectObjectIdentifier: SO01
Name (AZK OS OLL Oblouk kruhovy:AZK OS OLL Oblouk kruhovy:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3328995 | STŘECHA | TA02.81.88 | STŘECHA | SF.CH
3349956 | 1.S | TA02.81.89 | 1.S | EF.T
3358789 | 1.S | TA02.81.90 | 1.S | EF.H
3360031 | 1.S | TA02.81.91 | 1.S | EF.H
3360117 | 1.S | TA02.81.92 | 1.S | EF.H
3361384 | 1.S | TA02.81.93 | 1.S | EF.T
3374462 | 1.S | TA02.81.94 | 1.S | Mechanické Odvod vzduchu 4
3374485 | 1.S | TA02.81.95 | 1.S | Mechanické Odvod vzduchu 4
3374750 | 1.S | TA02.81.96 | 1.S | Mechanické Odvod vzduchu 5
3374754 | 1.S | TA02.81.97 | 1.S | Mechanické Odvod vzduchu 5
3389327 | 1.S | TA02.81.99 | 1.S | EF.H
3397186 | 5.NP | TA02.81.601 | 5.NP | Mechanické Odvod vzduchu 6

# IfcDuctFitting: AZK PCKA PCKS Prechod ctyrhranny na kruhovy:Standardní (9)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka - Přechod čtyřhranný na kruhový. Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectObjectIdentifier: SO01
Name (AZK PCKA PCKS Prechod ctyrhranny na kruhovy:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3328997 | STŘECHA | TA02.81.524 | STŘECHA | SF.CH
3355044 | 1.S | TA02.81.525 | 1.S | EF.G
3355340 | 1.S | TA02.81.526 | 1.S | EF.G2
3364895 | 1.NP | TA02.81.527 | 1.NP | EF.G
3365140 | 1.NP | TA02.81.528 | 1.NP | EF.G3
3370060 | 2.NP | TA02.81.529 | 2.NP | EF.G
3370169 | 2.NP | TA02.81.530 | 2.NP | EF.G4
3372431 | 3.NP | TA02.81.531 | 3.NP | EF.G
3372747 | 3.NP | TA02.81.532 | 3.NP | EF.G1

# IfcDuctFitting: AZK PRA PRS Prechod ctyrhranny:AZK PRA PRS Prechod ctyrhranny (17)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka potrubí - přechod čtyřhranný. Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.Přírubové profily jsou k potrubí upevněny vzájemným prolisováním nebo mohou být dle požadavku sbodovány. Rohové oblasti jsou utěsněny polyuretanovým tmelem.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK PRA PRS Prechod ctyrhranny; ElementProjectObjectIdentifier: SO01
Name (AZK PRA PRS Prechod ctyrhranny:AZK PRA PRS Prechod ctyrhranny:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3277426 | 1.S | TA02.81.100 | 1.S | EF.G2
3278320 | 1.S | TA02.81.101 | 1.S | EF.G2
3332392 | 1.S | TA02.81.102 | 1.S | EF.G
3335078 | 1.S | TA02.81.103 | 1.S | EF.G
3354373 | 1.S | TA02.81.104 | 1.S | EF.G
3358003 | 1.S | TA02.81.105 | 1.S | EF.G2
3358330 | 1.S | TA02.81.106 | 1.S | EF.G2
3363942 | 1.S | TA02.81.107 | 1.S | EF.G
3364281 | 1.NP | TA02.81.108 | 1.NP | EF.G
3367054 | 1.NP | TA02.81.109 | 1.NP | EF.G3
3367430 | 1.NP | TA02.81.110 | 1.NP | EF.G3
3369351 | 2.NP | TA02.81.111 | 2.NP | EF.G
3371961 | 2.NP | TA02.81.112 | 2.NP | EF.G4
3372067 | 2.NP | TA02.81.113 | 2.NP | EF.G4
3372445 | 3.NP | TA02.81.114 | 3.NP | EF.G1
3372447 | 3.NP | TA02.81.115 | 3.NP | EF.G1
3372570 | 3.NP | TA02.81.116 | 3.NP | EF.G

# IfcDuctFitting: AZK PRO PRE Prechod kruhovy:AZK PRO PRE Prechod kruhovy (7)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka potrubí - přechod kruhový. Kruhové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakost DX 51 D+Z 200 MAC.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK PRO PRE Prechod kruhovy; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Name (AZK PRO PRE Prechod kruhovy:AZK PRO PRE Prechod kruhovy:...) | Reference | Group
3252835 | TA02.81.117 | EF.H
3314071 | TA02.81.118 | EF.T
3349607 | TA02.81.119 | EF.T
3350215 | TA02.81.120 | EF.T
3359414 | TA02.81.121 | EF.H
3359530 | TA02.81.122 | EF.H
3360490 | TA02.81.123 | EF.H

# IfcDuctFitting: AZK ZAS Zaslep ctyrhranny:AZK ZAS Zaslep ctyrhranny (9)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TA02.81; ElementProjectSpecificDescription: Tvarovka - Záslep čtyrhranný. Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.Přírubové profily jsou k potrubí upevněny vzájemným prolisováním nebo mohou být dle požadavku sbodovány. Rohové oblasti jsou utěsněny polyuretanovým tmelem.
Type - CZ_DTcommon - DT_name: tvarovky VZT; DT_code: VZT.TV.T
CZ_ElementCommon - ElementProjectSpecificName: AZK ZAS Zaslep ctyrhranny; ElementProjectObjectIdentifier: SO01
Name (AZK ZAS Zaslep ctyrhranny:AZK ZAS Zaslep ctyrhranny:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3275517 | 1.S | TA02.81.137 | 1.S | EF.G2
3280022 | 1.S | TA02.81.138 | 1.S | EF.G2
3281259 | 1.NP | TA02.81.139 | 1.NP | EF.G3
3283673 | 1.NP | TA02.81.140 | 1.NP | EF.G3
3286366 | 2.NP | TA02.81.141 | 2.NP | EF.G4
3288774 | 3.NP | TA02.81.142 | 3.NP | EF.G1
3288960 | 3.NP | TA02.81.143 | 3.NP | EF.G1
3307466 | 2.NP | TA02.81.144 | 2.NP | EF.G4
3335100 | 1.S | TA02.81.145 | 1.S | EF.G

# IfcDuctSegment: Hranaté potrubí:spoje T - sk I. tř. 1+4 (95)
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PO02.80; ElementProjectSpecificDescription: Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.Přírubové profily jsou k potrubí upevněny vzájemným prolisováním nebo mohou být dle požadavku sbodovány. Rohové oblasti jsou utěsněny polyuretanovým tmelem.Standardní délky rovného potrubí jsou L=1000 mm, L=1500 mm.Potrubí větších rozměrů se dodatečně zpevňuje trubkovými výztuhami podle technického předpisu výrobce. Tyto výztuhy jsou tvořeny pozinkovanou trubkou, nylonovým středovým křížením a uchycením do pláště.Potrubí čtyřhranné ani jeho komponenty neobsahují silikon.Třídy těsnosti jsou podle ČSN EN 1507.Čtyřhranné potrubí se ve standardu dodává v třídě těsnosti A dle ČSN EN 1507.
Type - CZ_DTcommon - DT_name: vzduchotechnické potrubí VZT; DT_code: VZT.RO.P
CZ_ElementCommon - ElementProjectSpecificName: spoje T - sk I. tř. 1+4; ElementProjectObjectIdentifier: SO01
Name (Hranaté potrubí:spoje T - sk I. tř. 1+4:...) | In | Reference | StoreyProjectSpecificIdentifier = StoreyProjectSpecificIdentifier_ducts | Length | Group
3242570 | STŘECHA | PO02.80.301 | STŘECHA | 265 | SF.CH
3242611 | STŘECHA | PO02.80.302 | STŘECHA | 16795 | SF.CH
3243053 | STŘECHA | PO02.80.303 | STŘECHA | 247 | SF.CH
3254464 | 1.S | PO02.80.304 | 1.S | 21726 | EF.G2
3254800 | 1.S | PO02.80.305 | 1.S | 3851 | EF.G2
3254975 | 1.S | PO02.80.306 | 1.S | 9943 | EF.G2
3255026 | 1.NP | PO02.80.307 | 1.NP | 42183 | EF.G3
3255028 | 1.NP | PO02.80.308 | 1.NP | 4594 | EF.G3
3255031 | 1.NP | PO02.80.309 | 1.NP | 5619 | EF.G3
3255035 | 1.NP | PO02.80.310 | 1.NP | 9885 | EF.G3
3255047 | 2.NP | PO02.80.311 | 2.NP | 40483 | EF.G4
3255049 | 2.NP | PO02.80.312 | 2.NP | 5265 | EF.G4
3255052 | 2.NP | PO02.80.313 | 2.NP | 5753 | EF.G4
3255113 | 3.NP | PO02.80.314 | 3.NP | 20283 | EF.G1
3255115 | 3.NP | PO02.80.315 | 3.NP | 5265 | EF.G1
3255118 | 3.NP | PO02.80.316 | 3.NP | 5754 | EF.G1
3268614 | 1.S | PO02.80.317 | 1.S | 20515 | EF.G2
3274994 | 1.S | PO02.80.318 | 1.S | 10629 | EF.G2
3275012 | 1.S | PO02.80.319 | 1.S | 5950 | EF.G2
3275023 | 1.S | PO02.80.320 | 1.S | 12320 | EF.G2
3275127 | 1.S | PO02.80.321 | 1.S | 252 | EF.G2
3276191 | 1.S | PO02.80.322 | 1.S | 1035 | EF.G2
3276231 | 1.S | PO02.80.323 | 1.S | 28 | EF.G2
3276289 | 1.S | PO02.80.324 | 1.S | 11982 | EF.G2
3276296 | 1.S | PO02.80.325 | 1.S | 5695 | EF.G2
3277411 | 1.S | PO02.80.326 | 1.S | 23 | EF.G2
3280398 | 1.NP | PO02.80.327 | 1.NP | 5835 | EF.G3
3280407 | 1.NP | PO02.80.328 | 1.NP | 10210 | EF.G3
3280431 | 1.NP | PO02.80.329 | 1.NP | 12724 | EF.G3
3280438 | 1.NP | PO02.80.330 | 1.NP | 328 | EF.G3
3280462 | 1.NP | PO02.80.331 | 1.NP | 960 | EF.G3
3280593 | 1.NP | PO02.80.332 | 1.NP | 17 | EF.G3
3281608 | 1.NP | PO02.80.333 | 1.NP | 12634 | EF.G3
3283941 | 2.NP | PO02.80.334 | 2.NP | 12949 | EF.G4
3283942 | 2.NP | PO02.80.335 | 2.NP | 396 | EF.G4
3283944 | 2.NP | PO02.80.336 | 2.NP | 960 | EF.G4
3283998 | 2.NP | PO02.80.337 | 2.NP | 37 | EF.G4
3284034 | 2.NP | PO02.80.338 | 2.NP | 5903 | EF.G4
3284043 | 2.NP | PO02.80.339 | 2.NP | 10708 | EF.G4
3285017 | 2.NP | PO02.80.340 | 2.NP | 12881 | EF.G4
3286529 | 3.NP | PO02.80.341 | 3.NP | 12949 | EF.G1
3286530 | 3.NP | PO02.80.342 | 3.NP | 396 | EF.G1
3286532 | 3.NP | PO02.80.343 | 3.NP | 1010 | EF.G1
3286561 | 3.NP | PO02.80.344 | 3.NP | 36 | EF.G1
3286568 | 3.NP | PO02.80.345 | 3.NP | 12881 | EF.G1
3286595 | 3.NP | PO02.80.346 | 3.NP | 5903 | EF.G1
3286604 | 3.NP | PO02.80.347 | 3.NP | 10080 | EF.G1
3304306 | 1.S | PO02.80.348 | 1.S | 2579 | EF.G
3311537 | STŘECHA | PO02.80.349 | STŘECHA | 43 | SF.CH
3332380 | 1.S | PO02.80.350 | 1.S | 2668 | EF.G
3334756 | 1.S | PO02.80.351 | 1.S | 705 | EF.G
3354316 | 1.S | PO02.80.352 | 1.S | 30 | EF.G
3354362 | 1.S | PO02.80.353 | 1.S | 245 | EF.G
3354951 | 1.S | PO02.80.354 | 1.S | 40 | EF.G
3355298 | 1.S | PO02.80.355 | 1.S | 50 | EF.G2
3355450 | 1.S | PO02.80.356 | 1.S | 325 | EF.G2
3355677 | 1.S | PO02.80.357 | 1.S | 58 | EF.G2
3357181 | 1.S | PO02.80.358 | 1.S | 418 | EF.G2
3357191 | 1.S | PO02.80.359 | 1.S | 2714 | EF.G2
3357264 | 1.S | PO02.80.360 | 1.S | 32 | EF.G2
3357913 | 1.S | PO02.80.361 | 1.S | 59 | EF.G2
3357993 | 1.S | PO02.80.362 | 1.S | 80 | EF.G2
3358018 | 1.S | PO02.80.363 | 1.S | 10581 | EF.G2
3358318 | 1.S | PO02.80.364 | 1.S | 35 | EF.G2
3363935 | 1.S | PO02.80.365 | 1.S | 2103 | EF.G
3365302 | 1.NP | PO02.80.366 | 1.NP | 138 | EF.G3
3365309 | 1.NP | PO02.80.367 | 1.NP | 60 | EF.G3
3365974 | 1.NP | PO02.80.368 | 1.NP | 27 | EF.G3
3366241 | 1.NP | PO02.80.369 | 1.NP | 25 | EF.G3
3366383 | 1.NP | PO02.80.370 | 1.NP | 34 | EF.G3
3366581 | 1.NP | PO02.80.371 | 1.NP | 2238 | EF.G3
3367047 | 1.NP | PO02.80.372 | 1.NP | 20 | EF.G3
3367380 | 1.NP | PO02.80.373 | 1.NP | 21 | EF.G3
3367425 | 1.NP | PO02.80.374 | 1.NP | 33 | EF.G3
3367757 | 1.NP | PO02.80.375 | 1.NP | 10828 | EF.G3
3370483 | 2.NP | PO02.80.376 | 2.NP | 35 | EF.G4
3370727 | 2.NP | PO02.80.377 | 2.NP | 45 | EF.G4
3370900 | 2.NP | PO02.80.378 | 2.NP | 137 | EF.G4
3371132 | 2.NP | PO02.80.379 | 2.NP | 40 | EF.G4
3371198 | 2.NP | PO02.80.380 | 2.NP | 80 | EF.G4
3371654 | 2.NP | PO02.80.381 | 2.NP | 35 | EF.G4
3371954 | 2.NP | PO02.80.382 | 2.NP | 38 | EF.G4
3372060 | 2.NP | PO02.80.383 | 2.NP | 20 | EF.G4
3372095 | 2.NP | PO02.80.384 | 2.NP | 2466 | EF.G4
3372220 | 2.NP | PO02.80.385 | 2.NP | 11180 | EF.G4
3372436 | 3.NP | PO02.80.386 | 3.NP | 45 | EF.G1
3372437 | 3.NP | PO02.80.387 | 3.NP | 137 | EF.G1
3372439 | 3.NP | PO02.80.388 | 3.NP | 40 | EF.G1
3372440 | 3.NP | PO02.80.389 | 3.NP | 80 | EF.G1
3372443 | 3.NP | PO02.80.390 | 3.NP | 35 | EF.G1
3372444 | 3.NP | PO02.80.391 | 3.NP | 38 | EF.G1
3372446 | 3.NP | PO02.80.392 | 3.NP | 20 | EF.G1
3372740 | 3.NP | PO02.80.393 | 3.NP | 74 | EF.G1
3373050 | 3.NP | PO02.80.394 | 3.NP | 2466 | EF.G1
3373372 | 3.NP | PO02.80.395 | 3.NP | 11180 | EF.G1

# IfcDuctSegment: Hranaté potrubí:spoje V - sk I. tř. 1+4 (15)
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PO02.80; ElementProjectSpecificDescription: Čtyřhranné ocelové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakosti DX 51 D+Z 200 MAC. Ke spojování potrubí se používá přírubová lišta.Přírubové profily jsou k potrubí upevněny vzájemným prolisováním nebo mohou být dle požadavku sbodovány. Rohové oblasti jsou utěsněny polyuretanovým tmelem.Standardní délky rovného potrubí jsou L=1000 mm, L=1500 mm.Potrubí větších rozměrů se dodatečně zpevňuje trubkovými výztuhami podle technického předpisu výrobce. Tyto výztuhy jsou tvořeny pozinkovanou trubkou, nylonovým středovým křížením a uchycením do pláště.Potrubí čtyřhranné ani jeho komponenty neobsahují silikon.Třídy těsnosti jsou podle ČSN EN 1507.Čtyřhranné potrubí se ve standardu dodává v třídě těsnosti A dle ČSN EN 1507.
Type - CZ_DTcommon - DT_name: vzduchotechnické potrubí VZT; DT_code: VZT.RO.P
CZ_ElementCommon - ElementProjectSpecificName: spoje V - sk I. tř. 1+4; ElementProjectObjectIdentifier: SO01
Name (Hranaté potrubí:spoje V - sk I. tř. 1+4:...) | In | Reference | StoreyProjectSpecificIdentifier = StoreyProjectSpecificIdentifier_ducts | Length | Group
3243327 | STŘECHA | PO02.80.479 | STŘECHA | 217 | SF.CH
3243338 | STŘECHA | PO02.80.480 | STŘECHA | 217 | SF.CH
3243353 | STŘECHA | PO02.80.481 | STŘECHA | 217 | SF.CH
3243366 | STŘECHA | PO02.80.482 | STŘECHA | 217 | SF.CH
3243377 | STŘECHA | PO02.80.483 | STŘECHA | 224 | SF.CH
3334733 | 1.S | PO02.80.484 | 1.S | 5270 | EF.G
3364135 | 1.NP | PO02.80.485 | 1.NP | 110 | EF.G
3364145 | 1.NP | PO02.80.486 | 1.NP | 50 | EF.G
3364836 | 1.NP | PO02.80.487 | 1.NP | 20 | EF.G
3369284 | 2.NP | PO02.80.488 | 2.NP | 6 | EF.G
3369340 | 2.NP | PO02.80.489 | 2.NP | 48 | EF.G
3369716 | 2.NP | PO02.80.490 | 2.NP | 51 | EF.G
3372426 | 3.NP | PO02.80.491 | 3.NP | 81 | EF.G
3372430 | 3.NP | PO02.80.492 | 3.NP | 11 | EF.G
3372562 | 3.NP | PO02.80.493 | 3.NP | 28 | EF.G

# IfcDuctSegment: Kulaté ohebné potrubí:Ohebná hadice SONOFLEX MI (4)
In: 1.S
Type - PredefinedType: FLEXIBLESEGMENT
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPC
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PO05.60; ElementProjectSpecificDescription: Ohebná Al laminátová hadice s vnitřním uspořádáním s tepelnou a hlukovou izolací z vrstvy ekologické nedráždivé minerální vaty tloušťky 25 mm, 16 kg/m3, parozábrana – zpevněný Al laminát. Vnitřní hadice je perforovaná jako tlumič hluku. Konstrukce obsahuje parotěsnou zábranu k zabránění kondenzace v hlukové izolaci.
Type - CZ_DTcommon - DT_name: ohebné potrubí VZT; DT_code: VZT.RO.O
CZ_ElementCommon - ElementProjectSpecificName: Ohebná hadice SONOFLEX MI; StoreyProjectSpecificIdentifier_ducts: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.H
Name (Kulaté ohebné potrubí:Ohebná hadice SONOFLEX MI:...) | Reference | StoreyProjectSpecificIdentifier | Length
3252739 | PO05.60.257 | 1.S | 263
3252832 | PO05.60.258 | 1.S | 425
3360138 | PO05.60.259 | 1.S | 398
3389348 | PO05.60.260 |  | 670

# IfcDuctSegment: Kulaté potrubí:spoje T - SPIRO těsnost C (83)
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PO02.70; ElementProjectSpecificDescription: Kruhové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakost DX 51 D+Z 200 MAC.U rovného potrubí SPIRO jsou spoje uzavírány spirálně vinutým falcem, u trouby hladké a prolamované jsou spoje uzavírány jednoduchým falcem anebo jsou bodovány. Případné kruhové příruby jsou lisované z pozinkovaného plechu, jejichž rozměry odpovídají normě ON 12 0517.Při spojování na vsunutí s těsněním jsou tvarové díly osazeny dvoubřitým pryžovým těsněním.Rovné potrubí se vyrábí na nasunutí, proto nelze osadit pryžovým těsněním.Potrubí kruhové ani jeho komponenty neobsahují silikon.Třídy těsnosti jsou podle DIN EN 1507. Kruhové tvarovky bez těsnění odpovídají třídě těsnosti A, kruhové tvarovky s těsněním odpovídají třídě těsnosti C.
Type - CZ_DTcommon - DT_name: vzduchotechnické potrubí VZT; DT_code: VZT.RO.P
CZ_ElementCommon - ElementProjectSpecificName: spoje T - SPIRO těsnost C; ElementProjectObjectIdentifier: SO01
Name (Kulaté potrubí:spoje T - SPIRO těsnost C:...) | In | Reference | StoreyProjectSpecificIdentifier = StoreyProjectSpecificIdentifier_ducts | Length | Group
3241055 | STŘECHA | PO02.70.396 | STŘECHA | 818 | SF.CH
3241332 | STŘECHA | PO02.70.397 | STŘECHA | 12 | SF.CH
3241452 | STŘECHA | PO02.70.398 | STŘECHA | 15 | SF.CH
3242415 | STŘECHA | PO02.70.399 | STŘECHA | 2173 | SF.CH
3244731 | 1.S | PO02.70.400 | 1.S | 215 | EF.T
3249946 | 1.S | PO02.70.401 | 1.S | 18444 | EF.H
3252756 | 1.S | PO02.70.402 | 1.S | 360 | EF.H
3292032 | 1.S | PO02.70.403 | 1.S | 9 | EF.G2
3292038 | 1.S | PO02.70.404 | 1.S | 15 | Mechanické Přívod vzduchu 2; EF.G
3294502 | 1.S | PO02.70.405 | 1.S | 175 | EF.H
3294815 | 1.S | PO02.70.406 | 1.S | 14 | EF.H
3294870 | 1.S | PO02.70.407 | 1.S | 19 | EF.H
3295290 | 1.S | PO02.70.408 | 1.S | 260 | EF.H
3295372 | 1.S | PO02.70.409 | 1.S | 14 | EF.H
3295375 | 1.S | PO02.70.410 | 1.S | 19 | EF.H
3313928 | 1.S | PO02.70.411 | 1.S | 310 | EF.T
3313932 | 1.S | PO02.70.412 | 1.S | 1845 | EF.T
3313936 | 1.S | PO02.70.413 | 1.S | 35 | EF.T
3313938 | 1.S | PO02.70.414 | 1.S | 120 | EF.T
3313941 | 1.S | PO02.70.415 | 1.S | 11 | EF.T
3313944 | 1.S | PO02.70.416 | 1.S | 16 | EF.T
3313947 | 1.S | PO02.70.417 | 1.S | 76 | EF.T
3313950 | 1.S | PO02.70.418 | 1.S | 158 | EF.T
3313953 | 1.S | PO02.70.419 | 1.S | 120 | EF.T
3313956 | 1.S | PO02.70.420 | 1.S | 11 | EF.T
3313959 | 1.S | PO02.70.421 | 1.S | 16 | EF.T
3313962 | 1.S | PO02.70.422 | 1.S | 76 | EF.T
3313965 | 1.S | PO02.70.423 | 1.S | 163 | EF.T
3313968 | 1.S | PO02.70.424 | 1.S | 120 | EF.T
3313971 | 1.S | PO02.70.425 | 1.S | 11 | EF.T
3313974 | 1.S | PO02.70.426 | 1.S | 16 | EF.T
3313977 | 1.S | PO02.70.427 | 1.S | 76 | EF.T
3313983 | 1.S | PO02.70.428 | 1.S | 222 | EF.T
3314116 | 1.S | PO02.70.429 | 1.S | 145 | EF.T
3314308 | 1.S | PO02.70.430 | 1.S | 206 | EF.T
3314974 | 1.S | PO02.70.431 | 1.S | 585 | EF.T
3328482 | STŘECHA | PO02.70.432 | STŘECHA | 188 | SF.CH
3345084 | 1.S | PO02.70.433 | 1.S | 2688 | EF.T
3345827 | 1.NP | PO02.70.434 | 1.NP | 11 | EF.G3; Mechanické Přívod vzduchu 1
3345851 | 1.NP | PO02.70.435 | 1.NP | 13 | EF.G
3346299 | 2.NP | PO02.70.436 | 2.NP | 26 | EF.G4
3346321 | 2.NP | PO02.70.437 | 2.NP | 18 | EF.G; Mechanické Přívod vzduchu 3
3346697 | 3.NP | PO02.70.438 | 3.NP | 7 | EF.G1
3346716 | 3.NP | PO02.70.439 | 3.NP | 18 | EF.G; Mechanické Přívod vzduchu 4
3346736 | 3.NP | PO02.70.440 | 3.NP | 34 | EF.G1
3349475 | 1.S | PO02.70.441 | 1.S | 84 | EF.T
3349503 | 1.S | PO02.70.442 | 1.S | 283 | EF.T
3349814 | 1.S | PO02.70.443 | 1.S | 11 | EF.T
3349983 | 1.S | PO02.70.444 | 1.S | 10 | EF.T
3350116 | 1.S | PO02.70.445 | 1.S | 82 | EF.T
3355210 | 1.S | PO02.70.446 | 1.S | 130 | EF.G
3355262 | 1.S | PO02.70.447 | 1.S | 55 | EF.G2
3358637 | 1.S | PO02.70.448 | 1.S | 67 | EF.H
3359212 | 1.S | PO02.70.449 | 1.S | 163 | EF.H
3359402 | 1.S | PO02.70.450 | 1.S | 83 | EF.H
3359494 | 1.S | PO02.70.451 | 1.S | 110 | EF.H
3359664 | 1.S | PO02.70.452 | 1.S | 98 | EF.H
3360015 | 1.S | PO02.70.453 | 1.S | 165 | EF.H
3360025 | 1.S | PO02.70.454 | 1.S | 570 | EF.H
3360107 | 1.S | PO02.70.455 | 1.S | 205 | EF.H
3360398 | 1.S | PO02.70.456 | 1.S | 43 | EF.H
3360449 | 1.S | PO02.70.457 | 1.S | 436 | EF.H
3360964 | 1.S | PO02.70.458 | 1.S | 123 | EF.H
3361351 | 1.S | PO02.70.459 | 1.S | 1786 | EF.T
3365061 | 1.NP | PO02.70.460 | 1.NP | 55 | EF.G
3365090 | 1.NP | PO02.70.461 | 1.NP | 71 | EF.G3
3369405 | 2.NP | PO02.70.462 | 2.NP | 60 | EF.G
3370099 | 2.NP | PO02.70.463 | 2.NP | 55 | EF.G4
3372630 | 3.NP | PO02.70.464 | 3.NP | 46 | EF.G
3374448 | 1.S | PO02.70.465 | 1.S | 917 | Mechanické Odvod vzduchu 4
3374456 | 1.S | PO02.70.466 | 1.S | 245 | Mechanické Odvod vzduchu 4
3374468 | 1.S | PO02.70.467 | 1.S | 148 | Mechanické Odvod vzduchu 4
3374746 | 1.S | PO02.70.468 | 1.S | 917 | Mechanické Odvod vzduchu 5
3374748 | 1.S | PO02.70.469 | 1.S | 245 | Mechanické Odvod vzduchu 5
3374752 | 1.S | PO02.70.470 | 1.S | 148 | Mechanické Odvod vzduchu 5
3385872 | 5.NP | PO02.70.476 | 5.NP | 1594 | Mechanické Odvod vzduchu 6
3389307 | 1.S | PO02.70.477 | 1.S | 925 | EF.H
3389319 | 1.S | PO02.70.478 | 1.S | 145 | EF.H
3395816 | 5.NP | PO02.70.620 | 5.NP | 253 | Mechanické Odvod vzduchu 6
3395888 | 5.NP | PO02.70.621 | 5.NP | 218 | Mechanické Odvod vzduchu 6
3395989 | 5.NP | PO02.70.622 | 5.NP | 17 | Mechanické Odvod vzduchu 6
3396053 | 5.NP | PO02.70.623 | 5.NP | 22 | Mechanické Odvod vzduchu 6
3396268 | 5.NP | PO02.70.624 | 5.NP | 157 | Mechanické Odvod vzduchu 6

# IfcPipeFitting: M_Koleno, obecné:Standardní (34)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PO06.85; ElementProjectSpecificDescription: Měděné Cu potrubí, provedení chladiva
Type - CZ_DTcommon - DT_name: vzduchotechnické potrubí VZT; DT_code: VZT.RO.P
CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectObjectIdentifier: SO01
Qto_DuctSegmentBaseQuantities - Length: 20
Name (M_Koleno, obecné:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3338657 | 1.S | PO06.85.494 | 1.S | Cu potrubí - plyn 10
3338924 | 1.S | PO06.85.495 | 1.S | Cu potrubí - plyn 9
3338928 | 1.S | PO06.85.496 | 1.S | Cu potrubí - plyn 7
3338932 | 1.S | PO06.85.497 | 1.S | Cu potrubí - plyn 8
3361643 | 1.S | PO06.85.498 | 1.S | Cu potrubí - plyn 2
3361682 | 1.S | PO06.85.499 | 1.S | Cu potrubí - plyn 1
3362977 | 1.S | PO06.85.500 | 1.S | Cu potrubí - plyn 4
3362979 | 1.S | PO06.85.501 | 1.S | Cu potrubí - plyn 4
3362986 | 1.S | PO06.85.502 | 1.S | Cu potrubí - plyn 3
3362988 | 1.S | PO06.85.503 | 1.S | Cu potrubí - plyn 3
3362995 | 1.S | PO06.85.504 | 1.S | Cu potrubí - plyn 2
3362997 | 1.S | PO06.85.505 | 1.S | Cu potrubí - plyn 2
3363004 | 1.S | PO06.85.506 | 1.S | Cu potrubí - plyn 1
