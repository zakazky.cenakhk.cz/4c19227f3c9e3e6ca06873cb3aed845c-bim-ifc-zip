Properties of the parts of a building model (IFC4), part 3 of 3

# IfcPipeFitting: M_Koleno, obecné:Standardní (34)
Name (M_Koleno, obecné:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3363006 | 1.S | PO06.85.507 | 1.S | Cu potrubí - plyn 1
3363258 | 1.S | PO06.85.508 | 1.S | Cu potrubí - plyn 6
3363260 | 1.S | PO06.85.509 | 1.S | Cu potrubí - plyn 6
3363267 | 1.S | PO06.85.510 | 1.S | Cu potrubí - plyn 5
3363269 | 1.S | PO06.85.511 | 1.S | Cu potrubí - plyn 5
3363659 | 1.S | PO06.85.512 | 1.S | Cu potrubí - plyn 8
3363683 | 1.S | PO06.85.513 | 1.S | Cu potrubí - plyn 7
3363761 | 1.S | PO06.85.514 | 1.S | Cu potrubí - plyn 9
3363797 | 1.S | PO06.85.515 | 1.S | Cu potrubí - plyn 10
3363821 | 1.S | PO06.85.516 | 1.S | Cu potrubí - plyn 10
3363823 | 1.S | PO06.85.517 | 1.S | Cu potrubí - plyn 10
3363842 | 1.S | PO06.85.518 | 1.S | Cu potrubí - plyn 9
3363844 | 1.S | PO06.85.519 | 1.S | Cu potrubí - plyn 9
3363851 | 1.S | PO06.85.520 | 1.S | Cu potrubí - plyn 7
3363853 | 1.S | PO06.85.521 | 1.S | Cu potrubí - plyn 7
3363860 | 1.S | PO06.85.522 | 1.S | Cu potrubí - plyn 8
3363862 | 1.S | PO06.85.523 | 1.S | Cu potrubí - plyn 8
3397517 | 5.NP | PO06.85.616 | 5.NP | Cu potrubí - plyn 11
3397519 | 5.NP | PO06.85.617 | 5.NP | Cu potrubí - plyn 11
3397538 | 5.NP | PO06.85.618 | 5.NP | Cu potrubí - plyn 12
3397540 | 5.NP | PO06.85.619 | 5.NP | Cu potrubí - plyn 12

# IfcPipeSegment: Typy trubek:Cu potrubí (46)
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PO06.85; ElementProjectSpecificDescription: Měděné Cu potrubí, provedení chladiva
Type - CZ_DTcommon - DT_name: vzduchotechnické potrubí VZT; DT_code: VZT.RO.P
CZ_ElementCommon - ElementProjectSpecificName: Cu potrubí; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Name (Typy trubek:Cu potrubí:...) | In | Reference | StoreyProjectSpecificIdentifier_ducts | Length | Group
3337779 | 1.S | PO06.85.146 | 1.S | 422 | Cu potrubí - plyn 1
3337842 | 1.S | PO06.85.147 | 1.S | 377 | Cu potrubí - plyn 2
3338015 | 1.S | PO06.85.148 | 1.S | 889 | Cu potrubí - plyn 3
3338023 | 1.S | PO06.85.149 | 1.S | 422 | Cu potrubí - plyn 3
3338047 | 1.S | PO06.85.150 | 1.S | 872 | Cu potrubí - plyn 4
3338055 | 1.S | PO06.85.151 | 1.S | 382 | Cu potrubí - plyn 4
3338174 | 1.S | PO06.85.152 | 1.S | 2820 | Cu potrubí - plyn 5
3338262 | 1.S | PO06.85.153 | 1.S | 2802 | Cu potrubí - plyn 6
3338299 | 1.S | PO06.85.154 | 1.S | 167 | Cu potrubí - plyn 7
3338301 | 1.S | PO06.85.155 | 1.S | 135 | Cu potrubí - plyn 8
3338432 | 1.S | PO06.85.156 | 1.S | 5217 | Cu potrubí - plyn 8
3338476 | 1.S | PO06.85.157 | 1.S | 5285 | Cu potrubí - plyn 7
3338607 | 1.S | PO06.85.158 | 1.S | 5312 | Cu potrubí - plyn 9
3338609 | 1.S | PO06.85.159 | 1.S | 5295 | Cu potrubí - plyn 10
3338632 | 1.S | PO06.85.160 | 1.S | 1142 | Cu potrubí - plyn 9
3338634 | 1.S | PO06.85.161 | 1.S | 1125 | Cu potrubí - plyn 10
3361627 | 1.S | PO06.85.162 | 1.S | 1792 | Cu potrubí - plyn 2
3361637 | 1.S | PO06.85.163 | 1.S | 507 | Cu potrubí - plyn 2
3361668 | 1.S | PO06.85.164 | 1.S | 1774 | Cu potrubí - plyn 1
3361676 | 1.S | PO06.85.165 | 1.S | 467 | Cu potrubí - plyn 1
3362975 | 1.S | PO06.85.166 | 1.S | 646 | Cu potrubí - plyn 4
3362984 | 1.S | PO06.85.167 | 1.S | 646 | Cu potrubí - plyn 3
3362993 | 1.S | PO06.85.168 | 1.S | 646 | Cu potrubí - plyn 2
3363002 | 1.S | PO06.85.169 | 1.S | 646 | Cu potrubí - plyn 1
3363026 | 1.S | PO06.85.170 | 1.S | 382 | Cu potrubí - plyn 5
3363030 | 1.S | PO06.85.171 | 1.S | 352 | Cu potrubí - plyn 6
3363256 | 1.S | PO06.85.172 | 1.S | 646 | Cu potrubí - plyn 6
3363265 | 1.S | PO06.85.173 | 1.S | 646 | Cu potrubí - plyn 5
3363377 | 1.S | PO06.85.174 | 1.S | 400 | Cu potrubí - plyn 10
3363480 | 1.S | PO06.85.175 | 1.S | 424 | Cu potrubí - plyn 9
3363512 | 1.S | PO06.85.176 | 1.S | 450 | Cu potrubí - plyn 7
3363556 | 1.S | PO06.85.177 | 1.S | 473 | Cu potrubí - plyn 8
3363651 | 1.S | PO06.85.178 | 1.S | 275 | Cu potrubí - plyn 8
3363675 | 1.S | PO06.85.179 | 1.S | 294 | Cu potrubí - plyn 7
3363753 | 1.S | PO06.85.180 | 1.S | 299 | Cu potrubí - plyn 9
3363789 | 1.S | PO06.85.181 | 1.S | 306 | Cu potrubí - plyn 10
3363819 | 1.S | PO06.85.182 | 1.S | 646 | Cu potrubí - plyn 10
3363840 | 1.S | PO06.85.183 | 1.S | 646 | Cu potrubí - plyn 9
3363849 | 1.S | PO06.85.184 | 1.S | 646 | Cu potrubí - plyn 7
3363858 | 1.S | PO06.85.185 | 1.S | 646 | Cu potrubí - plyn 8
3395264 | 5.NP | PO06.85.603 | 5.NP | 326 | Cu potrubí - plyn 11
3395279 | 5.NP | PO06.85.604 | 5.NP | 1671 | Cu potrubí - plyn 11
3395352 | 5.NP | PO06.85.605 | 5.NP | 707 | Cu potrubí - plyn 11
3395387 | 5.NP | PO06.85.606 | 5.NP | 296 | Cu potrubí - plyn 12
3395391 | 5.NP | PO06.85.607 | 5.NP | 1631 | Cu potrubí - plyn 12
3395395 | 5.NP | PO06.85.608 | 5.NP | 707 | Cu potrubí - plyn 12

# IfcUnitaryEquipment: Systemair - Duct fan - AXC:AXC-355 (2)
Type - PredefinedType: AIRHANDLER; Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: GQB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VN02.01; ElementProjectSpecificDescription: Axiální ventilátor, je určeny pro přívod nebo odvod vzduchu o teplotě do 55 °C. Konstrukce ventilátoru umožňuje horizontální a vertikální instalaci ve venkovním i vnitřním prostředí.
Type - CZ_DTcommon - DT_name: ventilátor VZT; DT_code: VZT.KP.V
CZ_ElementCommon - ElementProjectSpecificName: AXC-355; ElementProjectObjectIdentifier: SO01
Name (Systemair - Duct fan - AXC:AXC-355:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3304710 | 2.NP | VN02.01.8 | 2.NP | EF.G4; Mechanické Přívod vzduchu 3
3307555 | 3.NP | VN02.01.9 | 3.NP | EF.G1; Mechanické Přívod vzduchu 4

# IfcUnitaryEquipment: Systemair - Duct fan - AXC:AXC-400 (2)
Type - PredefinedType: AIRHANDLER; Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: GQB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VN02.03; ElementProjectSpecificDescription: Axiální ventilátor, je určeny pro přívod nebo odvod vzduchu o teplotě do 55 °C. Konstrukce ventilátoru umožňuje horizontální a vertikální instalaci ve venkovním i vnitřním prostředí.
Type - CZ_DTcommon - DT_name: ventilátor VZT; DT_code: VZT.KP.V
CZ_ElementCommon - ElementProjectSpecificName: AXC-400; ElementProjectObjectIdentifier: SO01
Name (Systemair - Duct fan - AXC:AXC-400:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3292029 | 1.S | VN02.03.11 | 1.S | EF.G2; Mechanické Přívod vzduchu 2
3293985 | 1.NP | VN02.03.12 | 1.NP | EF.G; Mechanické Přívod vzduchu 1
