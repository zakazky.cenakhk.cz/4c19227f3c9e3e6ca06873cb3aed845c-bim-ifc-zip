Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: , VersionGUID: 256cc4b4-671f-444d-9c38-52d0971bf3f3, NumberOfSaves: 122], ExchangeRequirement [BuildingService], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: SO01-VZT.ifc
Time: 2025-04-14T15:17:12+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.0.11.19 (CSY) - IFC 23.4.1.0

# IfcProject
LongName: VYPLNIT / PRÁZDNÉ

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding, VYPLNIT NEBO NECHAT PRÁZDNÉ
LongName: VYPLNIT NEBO NECHAT PRÁZDNÉ

# IfcBuildingStorey: Podlaží:Podlaží - nulová úroveň (13)
In: VYPLNIT NEBO NECHAT PRÁZDNÉ
Name | LongName | Elevation (mm)
1.S | 1.S | 0
1.S MEZIPATRO | 1.S MEZIPATRO | 1500
1.NP | 1.NP | 3000
1.NP MEZIPATRO | 1.NP MEZIPATRO | 4500
2.NP | 2.NP | 6000
2.NP MEZIPATRO | 2.NP MEZIPATRO | 7500
3.NP | 3.NP | 9000
3.NP MEZIPATRO | 3.NP MEZIPATRO | 10500
4.NP | 4.NP | 12000
4.NP MEZIPATRO | 4.NP MEZIPATRO | 13500
5.NP | 5.NP | 15000
5.NP MEZIPATRO | 5.NP MEZIPATRO | 16500
STŘECHA | STŘECHA | 20200

# IfcAirTerminal: Krycí mřížka odvodní CIR _ Covering grille return CIR - KMK:AZK KMK 125 (4)
Type - Material: Výchozí Nový materiál
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV07.20; ElementProjectSpecificDescription: AZK KMK Krycí mřížka kruhová
Type - CZ_DTcommon - DT_name: krycí mřížka; DT_code: VZT.KP.M
CZ_ElementCommon - ElementProjectSpecificName: AZK KMK 125; ElementProjectObjectIdentifier: SO01
Name (Krycí mřížka odvodní CIR _ Covering grille return CIR - KMK:AZK KMK 125:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3313952 | 1.S | VV07.20.19 | 1.S | EF.T
3313967 | 1.S | VV07.20.20 | 1.S | EF.T
3313980 | 1.S | VV07.20.21 | 1.S | EF.T
3396190 | 5.NP | VV07.20.600 | 5.NP | Mechanické Odvod vzduchu 6

# IfcAirTerminal: Krycí mřížka odvodní CIR _ Covering grille return CIR - KMK:AZK KMK 160, Krycí mřížka odvodní CIR _ Covering grille return CIR - KMK:AZK KMK 160:3244786
In: 1.S
Type - Material: Výchozí Nový materiál
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV07.20; ElementProjectSpecificDescription: AZK KMK Krycí mřížka kruhová
Type - CZ_DTcommon - DT_name: krycí mřížka; DT_code: VZT.KP.M
CZ_ElementCommon - ElementProjectSpecificName: AZK KMK 160; Reference: VV07.20.22; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.T

# IfcAirTerminal: Krycí mřížka odvodní CIR _ Covering grille return CIR - KMK:AZK KMK 200, Krycí mřížka odvodní CIR _ Covering grille return CIR - KMK:AZK KMK 200:3314997
In: 1.S
Type - Material: Výchozí Nový materiál
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV07.20; ElementProjectSpecificDescription: AZK KMK Krycí mřížka kruhová
Type - CZ_DTcommon - DT_name: krycí mřížka; DT_code: VZT.KP.M
CZ_ElementCommon - ElementProjectSpecificName: AZK KMK 200; Reference: VV07.20.24; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.T

# IfcAirTerminal: Krycí mřížka přívodní REC _ Covering grille supply REC - KMC:AZK KMC Kryci mrizka ctyrhranna - privodni (6)
In: STŘECHA
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV07.20; ElementProjectSpecificDescription: Krycí mřížka čtyřhranná se používá k zakrytí volných konců čtyřhranného potrubí nebo k překrytí stavebních otvorů, průchodů apod. Krycí mřížka neslouží k zabránění vnik-nutí vody a sněhu.
Type - CZ_DTcommon - DT_name: krycí mřížka; DT_code: VZT.KP.M
CZ_ElementCommon - ElementProjectSpecificName: AZK KMC Kryci mrizka ctyrhranna - privodni; StoreyProjectSpecificIdentifier: STŘECHA; ElementProjectObjectIdentifier: SO01
Group: SF.CH
Name (Krycí mřížka přívodní REC _ Covering grille supply REC - KMC:AZK KMC Kryci mrizka ctyrhranna - privodni:...) | Reference
3243155 | VV07.20.13
3243328 | VV07.20.14
3243339 | VV07.20.15
3243354 | VV07.20.16
3243367 | VV07.20.17
3348635 | VV07.20.18

# IfcAirTerminal: Protidešťová žaluzie výfuk_ Rainprotective louvre exhaust - PRZ:Protideštová žaluzie, výfuk, na potrubí, Protidešťová žaluzie výfuk_ Rainprotective louvre exhaust - PRZ:Protideštová žaluzie, výfuk, na potrubí:3335221
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV08.50; ElementProjectSpecificDescription: AZK PRZ Protidestova zaluzie vyfuk
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: Protideštová žaluzie, výfuk, na potrubí; Reference: VV08.50.267; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.G

# IfcAirTerminal: Sací kus sešikmený CIR TKU_ Suction element cut CIR TKU:AZK TKU Trouba kruhova s ukosem (3)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV07.50; ElementProjectSpecificDescription: Trouba kruhová s úkosem včtně pletiva. Kruhové potrubí sk. I se vyrábí z ocelového hlubokotaženého pozinkovaného plechu jakost DX 51 D+Z 200 MAC.
Type - CZ_DTcommon - DT_name: koncový prvek VZT; DT_code: VZT.KP.P
CZ_ElementCommon - ElementProjectSpecificName: AZK TKU Trouba kruhova s ukosem; ElementProjectObjectIdentifier: SO01
Name (Sací kus sešikmený CIR TKU_ Suction element cut CIR TKU:AZK TKU Trouba kruhova s ukosem:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3241768 | STŘECHA | VV07.50.132 | STŘECHA | SF.CH
3374549 | 1.S | VV07.50.133 | 1.S | Mechanické Odvod vzduchu 4
3374756 | 1.S | VV07.50.134 | 1.S | Mechanické Odvod vzduchu 5

# IfcAirTerminal: Talířový ventil odvodní _ Disc valve return:KK 100 (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV02.18; ElementProjectSpecificDescription: Odvodní talířový ventil KK je vyroben z ocelového plechu opatřeného bílou barvou RAL 9003. Ventil má těsnění z pěnové hmoty. Nastavení průtoku se provádí otáčením regulačního kuželu do požadované polohy a zajištěním v poloze kontramatkou. Montážní kroužky KKL a KKT jsou vyrobeny z pozinkovaného ocelového plechu. Montážní kroužek KKT je opatřen jednobřitým těsněním.
Type - CZ_DTcommon - DT_name: koncový prvek VZT; DT_code: VZT.KP.P
CZ_ElementCommon - ElementProjectSpecificName: KK 100; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.H
Name (Talířový ventil odvodní _ Disc valve return:KK 100:...) | Reference
3249132 | VV02.18.192
3249251 | VV02.18.193

# IfcAirTerminal: Talířový ventil odvodní _ Disc valve return:KK 125 (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV02.20; ElementProjectSpecificDescription: Odvodní talířový ventil KK je vyroben z ocelového plechu opatřeného bílou barvou RAL 9003. Ventil má těsnění z pěnové hmoty. Nastavení průtoku se provádí otáčením regulačního kuželu do požadované polohy a zajištěním v poloze kontramatkou. Montážní kroužky KKL a KKT jsou vyrobeny z pozinkovaného ocelového plechu. Montážní kroužek KKT je opatřen jednobřitým těsněním.
Type - CZ_DTcommon - DT_name: koncový prvek VZT; DT_code: VZT.KP.P
CZ_ElementCommon - ElementProjectSpecificName: KK 125; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.H
Name (Talířový ventil odvodní _ Disc valve return:KK 125:...) | Reference
3248244 | VV02.20.194
3249467 | VV02.20.195

# IfcAirTerminal: Výfuková hlavice CIR _ Exhaust head CIR _ VHK:AZK VHK 125, Výfuková hlavice CIR _ Exhaust head CIR _ VHK:AZK VHK 125:3396766
In: STŘECHA
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV09.01; ElementProjectSpecificDescription: AZK VHK Vyfukova hlavice kruhova
Type - CZ_DTcommon - DT_name: výfukové hlavice VZT; DT_code: VZT.KP.H
CZ_ElementCommon - ElementProjectSpecificName: AZK VHK 125; Reference: VV07.50.601; StoreyProjectSpecificIdentifier: STŘECHA; ElementProjectObjectIdentifier: SO01
Group: Mechanické Odvod vzduchu 6

# IfcAirTerminal: Výfuková hlavice CIR _ Exhaust head CIR _ VHK:AZK VHK 160, Výfuková hlavice CIR _ Exhaust head CIR _ VHK:AZK VHK 160:3311898
In: STŘECHA
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV09.01; ElementProjectSpecificDescription: AZK VHK Vyfukova hlavice kruhova
Type - CZ_DTcommon - DT_name: výfukové hlavice VZT; DT_code: VZT.KP.H
CZ_ElementCommon - ElementProjectSpecificName: AZK VHK 160; Reference: VV09.01.135; StoreyProjectSpecificIdentifier: STŘECHA; ElementProjectObjectIdentifier: SO01
Group: EF.H

# IfcAirTerminal: Výustka do čtyřhranného potrubí odvodní REC _ Duct diffusor return REC _ NOVA A:Čtyřhranná výustka, do čtyřhranného potrubí - NOVA A - Odvodní (39)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RND
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VV07.20; ElementProjectSpecificDescription: Čtyřhranná vyústka z hliníku, nastavitelné lamely. Vyústky jsou vyrobeny z tvarovaných eloxovaných profilů.
Type - CZ_DTcommon - DT_name: koncový prvek VZT; DT_code: VZT.KP.P
CZ_ElementCommon - ElementProjectSpecificName: Čtyřhranná výustka, do čtyřhranného potrubí - NOVA A - Odvodní; ElementProjectObjectIdentifier: SO01
Name (Výustka do čtyřhranného potrubí odvodní REC _ Duct diffusor return REC _ NOVA A:Čtyřhranná výustka, do čtyřhranného potrubí - NOVA A - Odvodní:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3275415 | 1.S | VV07.20.554 | 1.S | EF.G2
3275978 | 1.S | VV07.20.555 | 1.S | EF.G2
3276065 | 1.S | VV07.20.556 | 1.S | EF.G2
3277905 | 1.S | VV07.20.557 | 1.S | EF.G2
3278065 | 1.S | VV07.20.558 | 1.S | EF.G2
3278543 | 1.S | VV07.20.559 | 1.S | EF.G2
3278748 | 1.S | VV07.20.560 | 1.S | EF.G2
3278912 | 1.S | VV07.20.561 | 1.S | EF.G2
3279198 | 1.S | VV07.20.562 | 1.S | EF.G2
3279755 | 1.S | VV07.20.563 | 1.S | EF.G2
3279904 | 1.S | VV07.20.564 | 1.S | EF.G2
3280867 | 1.NP | VV07.20.565 | 1.NP | EF.G3
3281004 | 1.NP | VV07.20.566 | 1.NP | EF.G3
3281140 | 1.NP | VV07.20.567 | 1.NP | EF.G3
3281742 | 1.NP | VV07.20.568 | 1.NP | EF.G3
3282233 | 1.NP | VV07.20.569 | 1.NP | EF.G3
3282611 | 1.NP | VV07.20.570 | 1.NP | EF.G3
3282851 | 1.NP | VV07.20.571 | 1.NP | EF.G3
3283015 | 1.NP | VV07.20.572 | 1.NP | EF.G3
3283149 | 1.NP | VV07.20.573 | 1.NP | EF.G3
3283424 | 1.NP | VV07.20.574 | 1.NP | EF.G3
3283595 | 1.NP | VV07.20.575 | 1.NP | EF.G3
3284481 | 2.NP | VV07.20.576 | 2.NP | EF.G4
3284699 | 2.NP | VV07.20.577 | 2.NP | EF.G4
3284785 | 2.NP | VV07.20.578 | 2.NP | EF.G4
3285186 | 2.NP | VV07.20.579 | 2.NP | EF.G4
3285298 | 2.NP | VV07.20.580 | 2.NP | EF.G4
3285600 | 2.NP | VV07.20.581 | 2.NP | EF.G4
3285820 | 2.NP | VV07.20.582 | 2.NP | EF.G4
3286020 | 2.NP | VV07.20.583 | 2.NP | EF.G4
3286203 | 2.NP | VV07.20.584 | 2.NP | EF.G4
3286842 | 3.NP | VV07.20.585 | 3.NP | EF.G1
3286984 | 3.NP | VV07.20.586 | 3.NP | EF.G1
3287174 | 3.NP | VV07.20.587 | 3.NP | EF.G1
3287649 | 3.NP | VV07.20.588 | 3.NP | EF.G1
3287839 | 3.NP | VV07.20.589 | 3.NP | EF.G1
3288250 | 3.NP | VV07.20.590 | 3.NP | EF.G1
3288475 | 3.NP | VV07.20.591 | 3.NP | EF.G1
3288874 | 3.NP | VV07.20.592 | 3.NP | EF.G1

# IfcBuildingElementProxy: Obecné - Kondenzační jednotka:ACC Condensing unit (9)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: ECC
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ML05.01; ElementProjectSpecificDescription: Venkovní kondenzační jednotka chladivového systému.
Type - CZ_DTcommon - DT_name: další prvky; DT_code: OTH
CZ_ElementCommon - ElementProjectSpecificName: ACC Condensing unit; ElementProjectObjectIdentifier: SO01
Name (Obecné - Kondenzační jednotka:ACC Condensing unit:...) | In | Reference | StoreyProjectSpecificIdentifier
3310536 | 1.S | ML05.01.1 | 1.S
3310964 | 1.S | ML05.01.2 | 1.S
3312349 | 1.S | ML05.01.3 | 1.S
3312874 | 1.S | ML05.01.4 | 1.S
3312882 | 1.S | ML05.01.5 | 1.S
3315181 | 1.S MEZIPATRO | ML05.01.6 | 1.S MEZIPATRO
3315253 | 1.S | ML05.01.7 | 1.S
3392875 | 5.NP MEZIPATRO | ML05.01.6 | 5.NP MEZIPATRO
3393379 | 5.NP MEZIPATRO | ML05.01.2 | 5.NP MEZIPATRO

# IfcBuildingElementProxy: Obecné - Nástěnná klimatizační jednotka:Wallmounted unit (6)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: ECC
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ML01.01; ElementProjectSpecificDescription: Vnitřní nástěnná jednotka
Type - CZ_DTcommon - DT_name: další prvky; DT_code: OTH
CZ_ElementCommon - ElementProjectSpecificName: Wallmounted unit; ElementProjectObjectIdentifier: SO01
Name (Obecné - Nástěnná klimatizační jednotka:Wallmounted unit:...) | In | Reference | StoreyProjectSpecificIdentifier
3312966 | 1.S | ML01.01.542 | 1.S
3313231 | 1.S | ML01.01.543 | 1.S
3313419 | 1.S | ML01.01.544 | 1.S
3313756 | 1.S | ML01.01.545 | 1.S
3313835 | 1.S | ML01.01.546 | 1.S
3392874 | 5.NP | ML01.01.545 | 5.NP

# IfcBuildingElementProxy: Požární stěnový uzávěr _ Fire wallshutter _ FDML:Požární stěnový uzávěr _ Fire wallshutter _ FDML, Požární stěnový uzávěr _ Fire wallshutter _ FDML:Požární stěnový uzávěr _ Fire wallshutter _ FDML:3382861
In: 5.NP
Type - Material: Mřížka, <Unnamed>, Sanita
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: FMA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: PV02.40; ElementProjectSpecificDescription: Požární stěnový uzávěr
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: Požární stěnový uzávěr _ Fire wallshutter _ FDML; Reference: PV02.40.261; StoreyProjectSpecificIdentifier: 5.NP; ElementProjectObjectIdentifier: SO01

# IfcBuildingElementProxy: Prostup CIR _ Penetration CIR:Prostup CIR _ Penetration CIR (4)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: KEC
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: MT01.01; ElementProjectSpecificDescription: Prostup potrubí
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: Prostup CIR _ Penetration CIR; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Name (Prostup CIR _ Penetration CIR:Prostup CIR _ Penetration CIR:...) | Reference | Group
3339844 | MT01.01.263 | Mechanické Odvod vzduchu 3
3340197 | MT01.01.264 | Mechanické Odvod vzduchu 8
3345034 | MT01.01.265 | EF.T
3363034 | MT01.01.266 | Mechanické Odvod vzduchu 1

# IfcBuildingElementProxy: Pružná manžeta CIR _ Flexible cuff CIR - TVK:Pružná manžeta CIR _ Flexible cuff CIR - TVK (10)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: MA01.01; ElementProjectSpecificDescription: Tlumící vložka slouží k zabránění přenosu chvění z ventilátoru nebo vzduchotech-nické jednotky apod. na navazující potrubní rozvod. Vložka je vyrobena z polotovaru pogumované textilní tkaniny, konce vložky můžou být osazeny přírubami. Tento výrobek lze dodat i v nerezovém provedení (odolnost až 200 °C) a v hygienické úpravě. Tlumící vložka není odolná vůči agresivním chemickým látkám a výparům.
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: Pružná manžeta CIR _ Flexible cuff CIR - TVK; ElementProjectObjectIdentifier: SO01
Name (Pružná manžeta CIR _ Flexible cuff CIR - TVK:Pružná manžeta CIR _ Flexible cuff CIR - TVK:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3345933 | 1.NP | MA01.01.282 | 1.NP | EF.G3
3345995 | 1.NP | MA01.01.283 | 1.NP | EF.G
3346348 | 2.NP | MA01.01.284 | 2.NP | EF.G4
3346413 | 2.NP | MA01.01.285 | 2.NP | EF.G
3346734 | 3.NP | MA01.01.286 | 3.NP | EF.G1
3346762 | 3.NP | MA01.01.287 | 3.NP | EF.G
3349812 | 1.S | MA01.01.288 | 1.S | EF.T
3349981 | 1.S | MA01.01.289 | 1.S | EF.T
3395971 | 5.NP | MA01.01.610 | 5.NP | Mechanické Odvod vzduchu 6
3396036 | 5.NP | MA01.01.611 | 5.NP | Mechanické Odvod vzduchu 6

# IfcBuildingElementProxy: Regulační klapka REC _ Regulation damper REC _ RKZ:Regulacni klapka ctyrhranna pozinkovana (9)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RNB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: LV02.17; ElementProjectSpecificDescription: AZK RKZ Regulacni klapka ctyrhranna pozinkovana
Type - CZ_DTcommon - DT_name: regulační a uzavírací ventil, klapka VZT; DT_code: VZT.KP.R
CZ_ElementCommon - ElementProjectSpecificName: Regulacni klapka ctyrhranna pozinkovana; ElementProjectObjectIdentifier: SO01
Name (Regulační klapka REC _ Regulation damper REC _ RKZ:Regulacni klapka ctyrhranna pozinkovana:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3311410 | STŘECHA | LV02.17.292 | STŘECHA | SF.CH
3357256 | 1.S | LV02.17.293 | 1.S | EF.G2
3357877 | 1.S | LV02.17.294 | 1.S | EF.G2
3366653 | 1.NP | LV02.17.295 | 1.NP | EF.G3
3366773 | 1.NP | LV02.17.296 | 1.NP | EF.G3
3371297 | 2.NP | LV02.17.297 | 2.NP | EF.G4
3371607 | 2.NP | LV02.17.298 | 2.NP | EF.G4
3372441 | 3.NP | LV02.17.299 | 3.NP | EF.G1
3372442 | 3.NP | LV02.17.300 | 3.NP | EF.G1

# IfcBuildingElementProxy: Systemair - Duct fan - AXC:AXC-400, Systemair - Duct fan - AXC:AXC-400:3240881
In: STŘECHA
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: GQB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VN02.03; ElementProjectSpecificDescription: Axiální ventilátor, je určeny pro přívod nebo odvod vzduchu o teplotě do 55 °C. Konstrukce ventilátoru umožňuje horizontální a vertikální instalaci ve venkovním i vnitřním prostředí.
Type - CZ_DTcommon - DT_name: ventilátor VZT; DT_code: VZT.KP.V
CZ_ElementCommon - ElementProjectSpecificName: AXC-400; Reference: VN02.03.10; StoreyProjectSpecificIdentifier: STŘECHA; ElementProjectObjectIdentifier: SO01
Group: SF.CH

# IfcBuildingElementProxy: Systemair - Duct fan - K:K 125 M sileo (6)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: GQB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VN02.01; ElementProjectSpecificDescription: Radiální kovový ventilátor pro kruhové potrubí.
Type - CZ_DTcommon - DT_name: ventilátor VZT; DT_code: VZT.KP.V
CZ_ElementCommon - ElementProjectSpecificName: K 125 M sileo; ElementProjectObjectIdentifier: SO01
Name (Systemair - Duct fan - K:K 125 M sileo:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3294452 | 1.S | VN02.01.186 | 1.S | EF.H
3295370 | 1.S | VN02.01.187 | 1.S | EF.H
3313940 | 1.S | VN02.01.188 | 1.S | EF.T
3313955 | 1.S | VN02.01.189 | 1.S | EF.T
3313970 | 1.S | VN02.01.190 | 1.S | EF.T
3395688 | 5.NP | VN02.01.189 | 5.NP | Mechanické Odvod vzduchu 6

# IfcBuildingElementProxy: Systemair - Duct fan - K:K 125 XL sileo, Systemair - Duct fan - K:K 125 XL sileo:3244667
In: 1.S
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: GQB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VN02.01; ElementProjectSpecificDescription: Circular Duct Fan
Type - CZ_DTcommon - DT_name: ventilátor VZT; DT_code: VZT.KP.V
CZ_ElementCommon - ElementProjectSpecificName: K 125 XL sileo; Reference: VN02.01.191; StoreyProjectSpecificIdentifier: 1.S; ElementProjectObjectIdentifier: SO01
Group: EF.T

# IfcBuildingElementProxy: Tlumič hluku REC _ Attenuator REC _ THCP:AZK THC Tlumic hluku ctyrhranny (8)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TC02.05; ElementProjectSpecificDescription: AZK THC Tlumic hluku ctyrhranny
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: AZK THC Tlumic hluku ctyrhranny; ElementProjectObjectIdentifier: SO01
Name (Tlumič hluku REC _ Attenuator REC _ THCP:AZK THC Tlumic hluku ctyrhranny:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3354464 | 1.S | TC02.05.124 | 1.S | EF.G
3355573 | 1.S | TC02.05.125 | 1.S | EF.G2
3364323 | 1.NP | TC02.05.126 | 1.NP | EF.G
3365533 | 1.NP | TC02.05.127 | 1.NP | EF.G3
3369565 | 2.NP | TC02.05.128 | 2.NP | EF.G
3370659 | 2.NP | TC02.05.129 | 2.NP | EF.G4
3372429 | 3.NP | TC02.05.130 | 3.NP | EF.G
3372435 | 3.NP | TC02.05.131 | 3.NP | EF.G1

# IfcBuildingElementProxy: Zpětná klapka CIR _ Backdraft damper CIR:Zpětná klapka CIR _ Backdraft damper CIR (7)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RMB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: LV01.10; ElementProjectSpecificDescription: Zpětná klapka kruhová, vyrobená z pozinkovaného plechu. Motýlové provedení.
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: Zpětná klapka CIR _ Backdraft damper CIR; ElementProjectObjectIdentifier: SO01
Name (Zpětná klapka CIR _ Backdraft damper CIR:Zpětná klapka CIR _ Backdraft damper CIR:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3313949 | 1.S | LV01.10.547 | 1.S | EF.T
3313964 | 1.S | LV01.10.548 | 1.S | EF.T
3313979 | 1.S | LV01.10.549 | 1.S | EF.T
3350114 | 1.S | LV01.10.550 | 1.S | EF.T
3359645 | 1.S | LV01.10.551 | 1.S | EF.H
3360946 | 1.S | LV01.10.552 | 1.S | EF.H
3396266 | 5.NP | LV01.10.620 | 5.NP | Mechanické Odvod vzduchu 6

# IfcCovering: Izolace potrubí:Minerální tepelná izolace s Al polepem, tl. 40 mm (51)
Type - PredefinedType: INSULATION
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RQA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: IZ01.90; ElementProjectSpecificDescription: Minerální tepelná izolace s Al polepem, tl. 40 mm
Type - CZ_DTcommon - DT_name: izolace potrubí VZT; DT_code: VZT.RO.I
Material: Minerální tepelná izolace, AL polep - 40 mm
CZ_ElementCommon - ElementProjectSpecificName: Minerální tepelná izolace s Al polepem, tl. 40 mm; ElementProjectObjectIdentifier: SO01
Name (Izolace potrubí:Minerální tepelná izolace s Al polepem, tl. 40 mm:...) | In | Reference | StoreyProjectSpecificIdentifier
3347634 | 1.NP | IZ01.90.196 | 1.S
3347635 | 1.NP | IZ01.90.197 | 1.S
3347636 | 1.NP | IZ01.90.198 | 1.S
3347905 | 4.NP | IZ01.90.199 | 3.NP
3357455 | 1.NP | IZ01.90.200 | 1.S
3357456 | 1.NP | IZ01.90.201 | 1.S
3357457 | 1.NP | IZ01.90.202 | 1.S
3357458 | 1.NP | IZ01.90.203 | 1.S
3357459 | 1.NP | IZ01.90.204 | 1.S
3357502 | 1.NP | IZ01.90.205 | 1.S
3357503 | 1.NP | IZ01.90.206 | 1.S
3357504 | 1.NP | IZ01.90.207 | 1.S
3357532 | 1.NP | IZ01.90.208 | 1.S
3357533 | 1.NP | IZ01.90.209 | 1.S
3367968 | 2.NP | IZ01.90.210 | 1.NP
3367969 | 2.NP | IZ01.90.211 | 1.NP
3367970 | 2.NP | IZ01.90.212 | 1.NP
3367971 | 2.NP | IZ01.90.213 | 1.NP
3367972 | 2.NP | IZ01.90.214 | 1.NP
3367982 | 2.NP | IZ01.90.215 | 1.NP
3367983 | 2.NP | IZ01.90.216 | 1.NP
3367984 | 2.NP | IZ01.90.217 | 1.NP
3367985 | 2.NP | IZ01.90.218 | 1.NP
3367986 | 2.NP | IZ01.90.219 | 1.NP
3367987 | 2.NP | IZ01.90.220 | 1.NP
3368007 | 2.NP | IZ01.90.221 | 1.NP
3368008 | 2.NP | IZ01.90.222 | 1.NP
3372638 | 4.NP | IZ01.90.223 | 3.NP
3373388 | 4.NP | IZ01.90.224 | 3.NP
3373389 | 4.NP | IZ01.90.225 | 3.NP
3373390 | 4.NP | IZ01.90.226 | 3.NP
3373391 | 4.NP | IZ01.90.227 | 3.NP
3373401 | 4.NP | IZ01.90.228 | 3.NP
3373402 | 4.NP | IZ01.90.229 | 3.NP
3373403 | 4.NP | IZ01.90.230 | 3.NP
3373404 | 4.NP | IZ01.90.231 | 3.NP
3373405 | 4.NP | IZ01.90.232 | 3.NP
3373441 | 4.NP | IZ01.90.233 | 3.NP
3373442 | 4.NP | IZ01.90.234 | 3.NP
3373448 | 3.NP | IZ01.90.235 | 2.NP
3373449 | 3.NP | IZ01.90.236 | 2.NP
3373450 | 3.NP | IZ01.90.237 | 2.NP
3373451 | 3.NP | IZ01.90.238 | 2.NP
3373452 | 3.NP | IZ01.90.239 | 2.NP
3373453 | 3.NP | IZ01.90.240 | 2.NP
3373454 | 3.NP | IZ01.90.241 | 2.NP
3373486 | 3.NP | IZ01.90.242 | 2.NP
3373487 | 3.NP | IZ01.90.243 | 2.NP
3373488 | 3.NP | IZ01.90.244 | 2.NP
3373489 | 3.NP | IZ01.90.245 | 2.NP
3373490 | 3.NP | IZ01.90.246 | 2.NP

# IfcCovering: Izolace potrubí:Minerální tepelná izolace s oplechováním, tl. 80 mm (10)
In: STŘECHA
Type - PredefinedType: INSULATION
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: RQA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: IZ01.90; ElementProjectSpecificDescription: Minerální tepelná izolace s oplechováním, tl. 80 mm
Type - CZ_DTcommon - DT_name: izolace potrubí VZT; DT_code: VZT.RO.I
Material: Minerální tepelná izolace, oplechování - 80 mm
CZ_ElementCommon - ElementProjectSpecificName: Minerální tepelná izolace s oplechováním, tl. 80 mm; StoreyProjectSpecificIdentifier: STŘECHA; ElementProjectObjectIdentifier: SO01
Name (Izolace potrubí:Minerální tepelná izolace s oplechováním, tl. 80 mm:...) | Reference
3349109 | IZ01.90.247
3349110 | IZ01.90.248
3349111 | IZ01.90.249
3349112 | IZ01.90.250
3349113 | IZ01.90.251
3349114 | IZ01.90.252
3349115 | IZ01.90.253
3349116 | IZ01.90.254
3349117 | IZ01.90.255
3349118 | IZ01.90.256

# IfcDamper: Pružná manžeta CIR _ Flexible cuff CIR - TVK:Pružná manžeta CIR _ Flexible cuff CIR - TVK (14)
Type - Material: <Unnamed>
Type - CZ_CCI - CCI_FunctionalSystemsCode: J; CCI_TechnicalSystemsCode: JJ; CCI_ComponentsCode: WPB
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: MA01.01; ElementProjectSpecificDescription: Tlumící vložka slouží k zabránění přenosu chvění z ventilátoru nebo vzduchotech-nické jednotky apod. na navazující potrubní rozvod. Vložka je vyrobena z polotovaru pogumované textilní tkaniny, konce vložky můžou být osazeny přírubami. Tento výrobek lze dodat i v nerezovém provedení (odolnost až 200 °C) a v hygienické úpravě. Tlumící vložka není odolná vůči agresivním chemickým látkám a výparům.
Type - CZ_DTcommon - DT_name: příslušenství VZT; DT_code: VZT.KP.Q
CZ_ElementCommon - ElementProjectSpecificName: Pružná manžeta CIR _ Flexible cuff CIR - TVK; ElementProjectObjectIdentifier: SO01
Name (Pružná manžeta CIR _ Flexible cuff CIR - TVK:Pružná manžeta CIR _ Flexible cuff CIR - TVK:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
3241290 | STŘECHA | MA01.01.268 | STŘECHA | SF.CH
3241393 | STŘECHA | MA01.01.269 | STŘECHA | SF.CH
3292034 | 1.S | MA01.01.270 | 1.S | EF.G2
3292037 | 1.S | MA01.01.271 | 1.S | EF.G
3294798 | 1.S | MA01.01.272 | 1.S | EF.H
3294844 | 1.S | MA01.01.273 | 1.S | EF.H
3295371 | 1.S | MA01.01.274 | 1.S | EF.H
3295374 | 1.S | MA01.01.275 | 1.S | EF.H
3313943 | 1.S | MA01.01.276 | 1.S | EF.T
3313946 | 1.S | MA01.01.277 | 1.S | EF.T
3313958 | 1.S | MA01.01.278 | 1.S | EF.T
3313961 | 1.S | MA01.01.279 | 1.S | EF.T
3313973 | 1.S | MA01.01.280 | 1.S | EF.T
3313976 | 1.S | MA01.01.281 | 1.S | EF.T

# IfcDistributionPort (1062)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_3241452_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3240881_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3240881_2 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3241332_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3241290_2 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3241055_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3241055_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3241768_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3241332_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3241290_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3241393_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3241452_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3328482_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3241393_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3242415_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3328995_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3328997_2 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242415_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3242570_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3311410_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3242625_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242570_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3242611_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242625_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243086_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242611_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243414_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242611_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243480_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242611_3 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243549_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242611_4 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243629_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242611_5 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3348524_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3242611_7 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243053_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243086_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243155_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243053_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243328_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243327_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243327_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243414_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243339_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243338_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243338_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243480_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243354_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243353_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243353_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243549_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243367_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243366_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243366_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243629_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3348635_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3243377_0 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3243377_1 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3348524_2 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3244667_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349814_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349983_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3244667_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3244731_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3244786_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3349607_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3244731_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3389348_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3248244_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3252832_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3249132_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3252739_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3249251_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360138_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3249467_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3249946_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3358789_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3311898_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3249946_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360490_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3252739_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3252786_4 | SINK | DUCT | VENTILATION | EF.H
OutPort_3252756_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3252756_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3252835_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3252786_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3389307_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3360449_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3252786_3 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3252835_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3252832_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3254464_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3278318_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3278320_3 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3254464_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254464_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3278912_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254464_3 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3279198_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254800_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3358367_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3268623_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3254800_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254800_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3278543_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3278318_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3254975_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254975_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3280022_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254975_3 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3279755_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3254975_4 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3279904_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3255034_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255026_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255026_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255036_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255026_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3282851_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255026_3 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3283015_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255026_4 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3283424_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255028_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255034_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3367845_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255028_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255028_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3282611_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255031_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3367766_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255033_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255031_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3281608_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255033_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255036_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3255035_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255035_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3283673_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255035_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3283149_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255035_3 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3283595_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3255055_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3255047_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255047_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3286366_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255047_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3285820_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255047_3 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3286020_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255047_4 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3286203_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255049_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3255055_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3372164_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3255049_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255049_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3285600_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255052_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3372302_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3285024_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3255052_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3255121_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3255113_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3255113_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3288774_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3255113_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3288475_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3255113_4 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3288874_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3255115_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3255121_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3373192_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3255115_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3255115_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3288250_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3255118_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3373377_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3287580_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3255118_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3268614_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3268623_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3268614_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3278320_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3268614_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3278748_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275021_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3274994_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3274994_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275517_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3274994_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275415_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275012_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275021_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275028_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275012_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275023_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275028_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275134_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275023_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275023_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275978_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275023_3 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276065_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3275127_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275134_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276166_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3275127_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276191_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276166_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276203_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276191_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276231_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276203_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3277428_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276231_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276289_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3277426_3 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276309_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276289_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276289_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3277905_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276289_3 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3278065_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3276296_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276309_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3358027_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3276296_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3277426_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3277411_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3277411_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3277428_2 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3280405_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280398_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280398_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280412_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280431_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280405_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280412_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280407_0 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280407_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3281259_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280407_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280867_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280445_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280431_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280431_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3281004_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280431_3 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3281140_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280438_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280445_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280469_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280438_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280462_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280469_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280563_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280462_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3280593_0 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280563_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3281615_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3280593_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3281608_1 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3281615_2 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3281608_2 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3281742_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3281608_3 | SINK | DUCT | VENTILATION | EF.G3
OutPort_3282233_1 | SOURCE | DUCT | VENTILATION | EF.G3
InPort_3283941_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284041_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283943_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283941_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283941_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284699_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283941_3 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284785_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283942_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283943_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283945_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283942_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283944_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283945_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283976_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283944_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3283998_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283976_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3284013_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3283998_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3285017_0 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284013_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3284041_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284034_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3284034_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284050_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3284050_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284043_0 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3284043_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3307466_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3284043_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3284481_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3285017_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3285024_2 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3285017_2 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3285186_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3285017_3 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3285298_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3286529_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286602_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286531_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286529_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286529_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286984_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286529_3 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3287174_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286530_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286531_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286533_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286530_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286532_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286533_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286534_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286532_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286561_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286534_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3287581_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286561_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286568_0 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3287580_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286568_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3287581_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286568_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3287649_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286568_3 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3287839_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286602_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286595_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286595_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286609_2 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286609_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286604_0 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286604_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3288960_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3286604_2 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3286842_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3292032_1 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3292029_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3292029_2 | SINK | DUCT | VENTILATION | Mechanické Přívod vzduchu 2
OutPort_3292038_0 | SOURCE | DUCT | VENTILATION | Mechanické Přívod vzduchu 2
InPort_3292034_2 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3292032_0 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3355262_0 | SINK | DUCT | VENTILATION | EF.G2
OutPort_3292034_1 | SOURCE | DUCT | VENTILATION | EF.G2
InPort_3292037_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3292038_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3355210_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3292037_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3293985_1 | SINK | DUCT | VENTILATION | Mechanické Přívod vzduchu 1
OutPort_3345827_1 | SOURCE | DUCT | VENTILATION | Mechanické Přívod vzduchu 1
InPort_3345851_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3293985_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3294452_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3294815_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3294870_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3294452_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3294502_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3359645_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359530_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3294502_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3294815_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3294798_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3294798_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3295290_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3294844_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3294870_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359402_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3294844_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3295290_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360448_4 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3295370_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3295372_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3295375_0 | SINK | DUCT | VENTILATION | EF.H
OutPort_3295370_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3295372_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3295371_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3295371_2 | SINK | DUCT | VENTILATION | EF.H
OutPort_3360015_0 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3295374_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3295375_1 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3359664_1 | SINK | DUCT | VENTILATION | EF.H
OutPort_3295374_2 | SOURCE | DUCT | VENTILATION | EF.H
InPort_3304306_0 | SINK | DUCT | VENTILATION | EF.G
OutPort_3332392_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3335078_3 | SINK | DUCT | VENTILATION | EF.G
OutPort_3304306_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3304306_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3369349_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3346299_1 | SINK | DUCT | VENTILATION | EF.G4
OutPort_3304710_1 | SOURCE | DUCT | VENTILATION | EF.G4
InPort_3304710_2 | SINK | DUCT | VENTILATION | Mechanické Přívod vzduchu 3
OutPort_3346321_1 | SOURCE | DUCT | VENTILATION | Mechanické Přívod vzduchu 3
InPort_3346697_1 | SINK | DUCT | VENTILATION | EF.G1
OutPort_3307555_1 | SOURCE | DUCT | VENTILATION | EF.G1
InPort_3307555_2 | SINK | DUCT | VENTILATION | Mechanické Přívod vzduchu 4
OutPort_3346716_1 | SOURCE | DUCT | VENTILATION | Mechanické Přívod vzduchu 4
InPort_3311410_2 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3311537_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3311537_0 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3328997_1 | SOURCE | DUCT | VENTILATION | SF.CH
Port_3312966_1 | SOURCEANDSINK | PIPE | HEATING
Port_3312966_2 | SOURCEANDSINK | PIPE | HEATING
Port_3313231_1 | SOURCEANDSINK | PIPE | HEATING
Port_3313231_2 | SOURCEANDSINK | PIPE | HEATING
Port_3313419_1 | SOURCEANDSINK | PIPE | HEATING
Port_3313419_2 | SOURCEANDSINK | PIPE | HEATING
Port_3313756_1 | SOURCEANDSINK | PIPE | HEATING
Port_3313756_2 | SOURCEANDSINK | PIPE | HEATING
Port_3313835_1 | SOURCEANDSINK | PIPE | HEATING
Port_3313835_2 | SOURCEANDSINK | PIPE | HEATING
InPort_3313930_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313928_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313928_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3314258_4 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313932_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313930_3 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313930_4 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313950_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313934_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313932_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313934_3 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313936_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313934_4 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313965_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313936_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3314071_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313943_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313938_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313938_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313952_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313940_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313944_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313941_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313940_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313946_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313941_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313944_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313943_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313947_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313946_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313949_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313947_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313950_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313949_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313958_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313953_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313953_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313967_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313955_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313959_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313956_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313955_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313961_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313956_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313959_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313958_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313962_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313961_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313964_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313962_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313965_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313964_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313973_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313968_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313968_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313980_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313970_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313974_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313971_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313970_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313976_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313971_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313974_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313973_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313977_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313976_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313979_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313977_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3313983_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313979_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3361384_3 | SINK | DUCT | VENTILATION | EF.T
OutPort_3313983_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3314071_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3361351_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3314258_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3314116_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3314116_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3350215_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3314258_3 | SINK | DUCT | VENTILATION | EF.T
OutPort_3345084_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3314308_0 | SINK | DUCT | VENTILATION | EF.T
OutPort_3349956_2 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3350215_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3314308_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3345034_2 | SINK | DUCT | VENTILATION | EF.T
OutPort_3314974_0 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3314974_1 | SINK | DUCT | VENTILATION | EF.T
OutPort_3314997_1 | SOURCE | DUCT | VENTILATION | EF.T
InPort_3328995_3 | SINK | DUCT | VENTILATION | SF.CH
OutPort_3328482_1 | SOURCE | DUCT | VENTILATION | SF.CH
InPort_3332380_0 | SINK | DUCT | VENTILATION | EF.G
OutPort_3363942_3 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3332392_3 | SINK | DUCT | VENTILATION | EF.G
OutPort_3332380_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3332380_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3364283_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3334733_0 | SINK | DUCT | VENTILATION | EF.G
OutPort_3335078_2 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3335081_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3334733_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3334733_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3372569_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3334756_0 | SINK | DUCT | VENTILATION | EF.G
OutPort_3335100_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3335221_1 | SINK | DUCT | VENTILATION | EF.G
OutPort_3334756_1 | SOURCE | DUCT | VENTILATION | EF.G
InPort_3334756_2 | SINK | DUCT | VENTILATION | EF.G
OutPort_3335081_1 | SOURCE | DUCT | VENTILATION | EF.G
Port_3337779_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3363006_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3337779_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 1
Port_3337842_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3362997_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3337842_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 2
Port_3338015_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3338015_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3362986_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3338023_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3362988_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3338023_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 3
Port_3338047_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3338047_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3362977_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3338055_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3362979_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3338055_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 4
Port_3338174_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3338174_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3363267_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 5
Port_3338262_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3363260_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3338262_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 6
Port_3338299_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3338928_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3338299_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3338301_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3338932_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3338301_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3338432_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3363659_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3338432_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3338932_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 8
Port_3338476_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3363683_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3338476_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3338928_2 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 7
Port_3338607_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3363761_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3338607_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3338924_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 9
Port_3338609_0 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
Port_3338657_1 | SOURCEANDSINK | PIPE | HEATING | Cu potrubí - plyn 10
