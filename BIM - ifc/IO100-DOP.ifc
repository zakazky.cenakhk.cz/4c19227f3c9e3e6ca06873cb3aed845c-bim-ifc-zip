Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 59b758ac-88a0-4971-9a6f-5812ac1433aa, NumberOfSaves: 66]
File name: C:\Users\Petr.Kadera\Downloads\SO01-teren (Revit2025, NEcloudovy).ifc
Time: 2025-01-27T19:07:23+01:00
Written by: ODA SDAI 24.11
Made in: Autodesk Revit 25.0.2.419 (CSY) - IFC 25.0.2.419

# IfcProject, 0001
LongName: Název projektu; Phase: Stav projektu

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:8mm záhlaví (3)
Name | LongName | Elevation (mm)
BPV | BPV | -439500
Podlaží 1 | Podlaží 1 | 0
Podlaží 2 | Podlaží 2 | 4000

# IfcBuildingElementProxy: Okolní objekty:Okolní objekty, Okolní objekty:Okolní objekty:447876
In: BPV
Type - Material: Obecný model
Type - CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Okolní objekty; ElementProjectSpecificDescription: okolní objekty; ElementProjectSpecificIdentifier: OO01
Type - CZ_DTcommon - DT_name: stávající objekty
CZ_ElementCommon - Reference: OO01.447876
CZ_CCI - CCI_BuiltSpacesCode: x

# IfcBuildingElementProxy: Výkopy:Custom Family -8584636062471725795, Výkopy:Custom Family -8584636062471725795:477932
In: BPV
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Custom Family -8584636062471725795
Type - CZ_DTcommon - DT_name: výkopy
Type - CZ_CCI - CCI_FunctionalSystemsCode: x; CCI_TechnicalSystemsCode: x; CCI_ComponentsCode: x
CZ_ElementCommon - Reference: .477932; ElementProjectSpecificDescription: Výkopy; ElementProjectSpecificIdentifier: V01
Qto_WallBaseQuantities - NetVolume: 15521.8

# IfcGeographicElement: Násyp:Násyp, Násyp:Násyp:467935
In: Podlaží 2
Type - PredefinedType: TERRAIN; Material: Násyp
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Násyp
CZ_ElementCommon - ElementProjectSpecificIdentifier: -; ElementProjectSpecificDescription: Násypy

# IfcGeographicElement: Násypy:Násypy, Násypy:Násypy:431183
In: BPV
Type - PredefinedType: TERRAIN; Material: Násyp
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Násypy; ElementProjectSpecificIdentifier: -; ElementProjectSpecificDescription: Násypy

# IfcGeographicElement: Terénní útvar:Cesta, Terénní útvar:Cesta:385573
In: Podlaží 1
Type - PredefinedType: TERRAIN; Material: Asfalt, vozovka, světle šedá
Type - CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Cesta; ElementProjectSpecificDescription: Pojízdné plochy; ElementProjectSpecificIdentifier: S03
Type - CZ_DTcommon - DT_name: silnice
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - Reference: S03.385573

# IfcGeographicElement: Terénní útvar:Cesta stávající, Terénní útvar:Cesta stávající:450196
In: Podlaží 1
Type - PredefinedType: TERRAIN; Material: Asfalt, vozovka, světle šedá
Type - CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Cesta stávající; ElementProjectSpecificDescription: Komunikace stávající; ElementProjectSpecificIdentifier: -
Type - CZ_DTcommon - DT_name: silnice
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - Reference: .450196

# IfcGeographicElement: Terénní útvar:Chodník (2)
In: Podlaží 1
Type - PredefinedType: TERRAIN; Material: Beton, litý na místě
Type - CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Chodník; ElementProjectSpecificDescription: Pochozí plochy; ElementProjectSpecificIdentifier: S01
Type - CZ_DTcommon - DT_name: silnice
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
Name (Terénní útvar:Chodník:...) | Reference
385397 | S01.385397
409007 | S01.409007

# IfcGeographicElement: Terénní útvar:Obecné – 1000 mm, Terénní útvar:Obecné – 1000 mm:457026
In: Podlaží 1
Type - PredefinedType: TERRAIN; Material: Tráva
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: -
CZ_ElementCommon - ElementProjectSpecificName: 02 - Stavajici teren + okoli; ElementProjectSpecificDescription: Zemina

# IfcGeographicElement: Terénní útvar:Parkování, Terénní útvar:Parkování:384317
In: Podlaží 1
Type - PredefinedType: TERRAIN; Material: Beton, litý na místě
Type - CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Parkování; ElementProjectSpecificDescription: Pojízdné parkovací plochy; ElementProjectSpecificIdentifier: SO04
Type - CZ_DTcommon - DT_name: silnice
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - Reference: SO04.384317

# IfcGeographicElement: Terénní útvar:Tráva, Terénní útvar:Tráva:384184
In: Podlaží 1
Type - PredefinedType: TERRAIN; Material: Tráva
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Tráva; ElementProjectSpecificIdentifier: -
CZ_ElementCommon - ElementProjectSpecificDescription: Zemina
