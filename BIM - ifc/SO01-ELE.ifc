Properties of the parts of a building model (IFC4), part 2 of 3

# IfcDistributionPort (1650)
Name | PredefinedType | SystemType
Port_1706206_1 | CABLE | ELECTRICAL
Port_1708840_1 | CABLE | ELECTRICAL
Port_1708852_1 | CABLE | ELECTRICAL
Port_1708863_1 | CABLE | ELECTRICAL
Port_1708874_1 | CABLE | ELECTRICAL
Port_1708885_1 | CABLE | ELECTRICAL
Port_1709746_1 | CABLE | ELECTRICAL
Port_1709748_1 | CABLE | ELECTRICAL
Port_1709749_1 | CABLE | ELECTRICAL
Port_1709750_1 | CABLE | ELECTRICAL
Port_1709751_1 | CABLE | ELECTRICAL
Port_1709752_1 | CABLE | ELECTRICAL
Port_1710012_1 | CABLE | ELECTRICAL
Port_1710566_1 | CABLE | ELECTRICAL
Port_1712655_1 | CABLE | ELECTRICAL
Port_1712662_1 | CABLE | ELECTRICAL
Port_1712680_1 | CABLE | ELECTRICAL
Port_1712686_1 | CABLE | ELECTRICAL
Port_1714691_1 | CABLE | ELECTRICAL
Port_1716654_1 | CABLE | ELECTRICAL
Port_1723489_3 | CABLE | ELECTRICAL
Port_1723489_4 | CABLE | ELECTRICAL
Port_1723489_5 | CABLE | ELECTRICAL
Port_1723489_6 | CABLE | ELECTRICAL
Port_1723489_7 | CABLE | ELECTRICAL
Port_1723914_3 | CABLE | ELECTRICAL
Port_1723914_4 | CABLE | ELECTRICAL
Port_1723914_5 | CABLE | ELECTRICAL
Port_1723914_6 | CABLE | ELECTRICAL
Port_1723914_7 | CABLE | ELECTRICAL
Port_1723920_3 | CABLE | ELECTRICAL
Port_1723920_4 | CABLE | ELECTRICAL
Port_1723920_5 | CABLE | ELECTRICAL
Port_1723920_6 | CABLE | ELECTRICAL
Port_1723920_7 | CABLE | ELECTRICAL
Port_1740019_1 | CABLE | ELECTRICAL
Port_1740019_4 | CABLE | ELECTRICAL
Port_1743337_3 | CABLE | ELECTRICAL
Port_1743337_4 | CABLE | ELECTRICAL
Port_1743337_5 | CABLE | ELECTRICAL
Port_1743337_6 | CABLE | ELECTRICAL
Port_1743337_7 | CABLE | ELECTRICAL
Port_1743778_3 | CABLE | ELECTRICAL
Port_1743778_4 | CABLE | ELECTRICAL
Port_1743778_5 | CABLE | ELECTRICAL
Port_1743778_6 | CABLE | ELECTRICAL
Port_1743778_7 | CABLE | ELECTRICAL
Port_1745404_3 | CABLE | ELECTRICAL
Port_1745404_4 | CABLE | ELECTRICAL
Port_1745404_5 | CABLE | ELECTRICAL
Port_1745404_6 | CABLE | ELECTRICAL
Port_1745404_7 | CABLE | ELECTRICAL
Port_1745599_3 | CABLE | ELECTRICAL
Port_1745599_4 | CABLE | ELECTRICAL
Port_1745599_5 | CABLE | ELECTRICAL
Port_1745599_6 | CABLE | ELECTRICAL
Port_1745599_7 | CABLE | ELECTRICAL
Port_1745652_3 | CABLE | ELECTRICAL
Port_1745652_4 | CABLE | ELECTRICAL
Port_1745652_5 | CABLE | ELECTRICAL
Port_1745652_6 | CABLE | ELECTRICAL
Port_1745652_7 | CABLE | ELECTRICAL
Port_1745843_3 | CABLE | ELECTRICAL
Port_1745843_4 | CABLE | ELECTRICAL
Port_1745843_5 | CABLE | ELECTRICAL
Port_1745843_6 | CABLE | ELECTRICAL
Port_1745843_7 | CABLE | ELECTRICAL
Port_1745849_3 | CABLE | ELECTRICAL
Port_1745849_4 | CABLE | ELECTRICAL
Port_1745849_5 | CABLE | ELECTRICAL
Port_1745849_6 | CABLE | ELECTRICAL
Port_1745849_7 | CABLE | ELECTRICAL
Port_1754914_3 | CABLE | ELECTRICAL
Port_1754914_4 | CABLE | ELECTRICAL
Port_1754914_5 | CABLE | ELECTRICAL
Port_1754914_6 | CABLE | ELECTRICAL
Port_1754914_7 | CABLE | ELECTRICAL
Port_1757122_3 | CABLE | ELECTRICAL
Port_1757122_4 | CABLE | ELECTRICAL
Port_1757122_5 | CABLE | ELECTRICAL
Port_1757122_6 | CABLE | ELECTRICAL
Port_1757122_7 | CABLE | ELECTRICAL
Port_1771390_0 | CABLECARRIER | CONVEYING
Port_2339778_2 | CABLECARRIER | CONVEYING
Port_1771390_1 | CABLECARRIER | CONVEYING
Port_1792692_0 | CABLECARRIER | CONVEYING
Port_1793288_1 | CABLECARRIER | CONVEYING
Port_1792692_1 | CABLECARRIER | CONVEYING
Port_1792725_1 | CABLECARRIER | CONVEYING
Port_1792725_2 | CABLECARRIER | CONVEYING
Port_1794644_0 | CABLECARRIER | CONVEYING
Port_1793188_0 | CABLECARRIER | CONVEYING
Port_1793288_3 | CABLECARRIER | CONVEYING
Port_1793188_1 | CABLECARRIER | CONVEYING
Port_1793288_2 | CABLECARRIER | CONVEYING
Port_1793289_1 | CABLECARRIER | CONVEYING
Port_1793289_0 | CABLECARRIER | CONVEYING
Port_1794488_0 | CABLECARRIER | CONVEYING
Port_1794694_2 | CABLECARRIER | CONVEYING
Port_1794488_1 | CABLECARRIER | CONVEYING
Port_2326340_1 | CABLECARRIER | CONVEYING
Port_1794644_1 | CABLECARRIER | CONVEYING
Port_2326208_2 | CABLECARRIER | CONVEYING
Port_1794694_0 | CABLECARRIER | CONVEYING
Port_1794694_1 | CABLECARRIER | CONVEYING
Port_1795443_2 | CABLECARRIER | CONVEYING
Port_1795443_0 | CABLECARRIER | CONVEYING
Port_2302122_2 | CABLECARRIER | CONVEYING
Port_1795443_1 | CABLECARRIER | CONVEYING
Port_1799177_0 | CABLECARRIER | CONVEYING
Port_2323862_2 | CABLECARRIER | CONVEYING
Port_1799177_1 | CABLECARRIER | CONVEYING
Port_2053024_11 | CABLECARRIER | CONVEYING
Port_1801848_0 | CABLECARRIER | CONVEYING
Port_2337967_2 | CABLECARRIER | CONVEYING
Port_1801848_1 | CABLECARRIER | CONVEYING
Port_2337969_1 | CABLECARRIER | CONVEYING
Port_1808219_1 | CABLE | ELECTRICAL
Port_1859834_1 | CABLE | ELECTRICAL
Port_1861242_1 | CABLE | ELECTRICAL
Port_1862867_1 | CABLE | ELECTRICAL
Port_1864737_1 | CABLE | ELECTRICAL
Port_1900134_1 | CABLE | ELECTRICAL
Port_1902976_1 | CABLE | ELECTRICAL
Port_1903719_1 | CABLE | ELECTRICAL
Port_1904497_1 | CABLE | ELECTRICAL
Port_1930778_1 | CABLE | ELECTRICAL
Port_1931652_1 | CABLE | ELECTRICAL
Port_1941757_1 | CABLE | ELECTRICAL
Port_1942785_1 | CABLE | ELECTRICAL
Port_1943059_1 | CABLE | ELECTRICAL
Port_1943294_1 | CABLE | ELECTRICAL
Port_1943727_1 | CABLE | ELECTRICAL
Port_1943778_1 | CABLE | ELECTRICAL
Port_1944904_1 | CABLE | ELECTRICAL
Port_1944954_1 | CABLE | ELECTRICAL
Port_1945307_1 | CABLE | ELECTRICAL
Port_1945874_1 | CABLE | ELECTRICAL
Port_1947383_1 | CABLE | ELECTRICAL
Port_1947547_1 | CABLE | ELECTRICAL
Port_1948917_1 | CABLE | ELECTRICAL
Port_1949322_1 | CABLE | ELECTRICAL
Port_1949479_1 | CABLE | ELECTRICAL
Port_1950758_1 | CABLE | ELECTRICAL
Port_1952595_1 | CABLE | ELECTRICAL
Port_1956053_1 | CABLE | ELECTRICAL
Port_1961293_1 | CABLE | ELECTRICAL
Port_1962600_1 | CABLE | ELECTRICAL
Port_1962884_1 | CABLE | ELECTRICAL
Port_1963344_1 | CABLE | ELECTRICAL
Port_1975681_1 | CABLE | ELECTRICAL
Port_1976972_1 | CABLE | ELECTRICAL
Port_2026269_1 | CABLE | ELECTRICAL
Port_2026281_1 | CABLE | ELECTRICAL
Port_2026297_1 | CABLE | ELECTRICAL
Port_2026311_1 | CABLE | ELECTRICAL
Port_2026323_1 | CABLE | ELECTRICAL
Port_2026335_1 | CABLE | ELECTRICAL
Port_2026349_1 | CABLE | ELECTRICAL
Port_2026363_1 | CABLE | ELECTRICAL
Port_2026383_1 | CABLE | ELECTRICAL
Port_2026395_1 | CABLE | ELECTRICAL
Port_2026407_1 | CABLE | ELECTRICAL
Port_2026417_1 | CABLE | ELECTRICAL
Port_2026433_1 | CABLE | ELECTRICAL
Port_2026451_1 | CABLE | ELECTRICAL
Port_2026471_1 | CABLE | ELECTRICAL
Port_2026481_1 | CABLE | ELECTRICAL
Port_2026493_1 | CABLE | ELECTRICAL
Port_2026505_1 | CABLE | ELECTRICAL
Port_2026644_1 | CABLE | ELECTRICAL
Port_2026661_1 | CABLE | ELECTRICAL
Port_2026673_1 | CABLE | ELECTRICAL
Port_2026687_1 | CABLE | ELECTRICAL
Port_2026703_1 | CABLE | ELECTRICAL
Port_2026717_1 | CABLE | ELECTRICAL
Port_2026731_1 | CABLE | ELECTRICAL
Port_2026751_1 | CABLE | ELECTRICAL
Port_2026767_1 | CABLE | ELECTRICAL
Port_2026777_1 | CABLE | ELECTRICAL
Port_2026791_1 | CABLE | ELECTRICAL
Port_2026809_1 | CABLE | ELECTRICAL
Port_2026817_1 | CABLE | ELECTRICAL
Port_2026835_1 | CABLE | ELECTRICAL
Port_2026849_1 | CABLE | ELECTRICAL
Port_2026867_1 | CABLE | ELECTRICAL
Port_2026883_1 | CABLE | ELECTRICAL
Port_2026899_1 | CABLE | ELECTRICAL
Port_2026909_1 | CABLE | ELECTRICAL
Port_2026923_1 | CABLE | ELECTRICAL
Port_2026937_1 | CABLE | ELECTRICAL
Port_2026951_1 | CABLE | ELECTRICAL
Port_2026963_1 | CABLE | ELECTRICAL
Port_2027029_1 | CABLE | ELECTRICAL
Port_2027053_1 | CABLE | ELECTRICAL
Port_2027653_1 | CABLE | ELECTRICAL
Port_2027931_1 | CABLE | ELECTRICAL
Port_2027949_1 | CABLE | ELECTRICAL
Port_2027971_1 | CABLE | ELECTRICAL
Port_2027979_1 | CABLE | ELECTRICAL
Port_2027991_1 | CABLE | ELECTRICAL
Port_2028017_1 | CABLE | ELECTRICAL
Port_2033344_1 | CABLE | ELECTRICAL
Port_2033358_1 | CABLE | ELECTRICAL
Port_2033374_1 | CABLE | ELECTRICAL
Port_2033388_1 | CABLE | ELECTRICAL
Port_2033398_1 | CABLE | ELECTRICAL
Port_2033412_1 | CABLE | ELECTRICAL
Port_2033430_1 | CABLE | ELECTRICAL
Port_2033442_1 | CABLE | ELECTRICAL
Port_2033456_1 | CABLE | ELECTRICAL
Port_2033476_1 | CABLE | ELECTRICAL
Port_2033490_1 | CABLE | ELECTRICAL
Port_2033502_1 | CABLE | ELECTRICAL
Port_2033518_1 | CABLE | ELECTRICAL
Port_2033532_1 | CABLE | ELECTRICAL
Port_2033548_1 | CABLE | ELECTRICAL
Port_2033566_1 | CABLE | ELECTRICAL
Port_2033580_1 | CABLE | ELECTRICAL
Port_2033592_1 | CABLE | ELECTRICAL
Port_2033606_1 | CABLE | ELECTRICAL
Port_2033618_1 | CABLE | ELECTRICAL
Port_2033632_1 | CABLE | ELECTRICAL
Port_2033646_1 | CABLE | ELECTRICAL
Port_2033658_1 | CABLE | ELECTRICAL
Port_2033670_1 | CABLE | ELECTRICAL
Port_2033692_1 | CABLE | ELECTRICAL
Port_2033710_1 | CABLE | ELECTRICAL
Port_2036098_1 | CABLE | ELECTRICAL
Port_2038677_1 | CABLE | ELECTRICAL
Port_2038685_1 | CABLE | ELECTRICAL
Port_2038693_1 | CABLE | ELECTRICAL
Port_2038705_1 | CABLE | ELECTRICAL
Port_2038721_1 | CABLE | ELECTRICAL
Port_2038735_1 | CABLE | ELECTRICAL
Port_2038747_1 | CABLE | ELECTRICAL
Port_2038769_1 | CABLE | ELECTRICAL
Port_2038793_1 | CABLE | ELECTRICAL
Port_2038805_1 | CABLE | ELECTRICAL
Port_2038817_1 | CABLE | ELECTRICAL
Port_2038829_1 | CABLE | ELECTRICAL
Port_2038841_1 | CABLE | ELECTRICAL
Port_2038855_1 | CABLE | ELECTRICAL
Port_2038867_1 | CABLE | ELECTRICAL
Port_2038885_1 | CABLE | ELECTRICAL
Port_2038901_1 | CABLE | ELECTRICAL
Port_2038919_1 | CABLE | ELECTRICAL
Port_2038929_1 | CABLE | ELECTRICAL
Port_2038943_1 | CABLE | ELECTRICAL
Port_2038957_1 | CABLE | ELECTRICAL
Port_2038971_1 | CABLE | ELECTRICAL
Port_2038983_1 | CABLE | ELECTRICAL
Port_2038997_1 | CABLE | ELECTRICAL
Port_2039019_1 | CABLE | ELECTRICAL
Port_2041349_1 | CABLE | ELECTRICAL
Port_2041363_1 | CABLE | ELECTRICAL
Port_2041381_1 | CABLE | ELECTRICAL
Port_2041397_1 | CABLE | ELECTRICAL
Port_2041415_1 | CABLE | ELECTRICAL
Port_2041441_1 | CABLE | ELECTRICAL
Port_2041453_1 | CABLE | ELECTRICAL
Port_2041465_1 | CABLE | ELECTRICAL
Port_2041479_1 | CABLE | ELECTRICAL
Port_2041491_1 | CABLE | ELECTRICAL
Port_2041501_1 | CABLE | ELECTRICAL
Port_2041511_1 | CABLE | ELECTRICAL
Port_2041527_1 | CABLE | ELECTRICAL
Port_2041545_1 | CABLE | ELECTRICAL
Port_2041561_1 | CABLE | ELECTRICAL
Port_2041577_1 | CABLE | ELECTRICAL
Port_2041591_1 | CABLE | ELECTRICAL
Port_2041607_1 | CABLE | ELECTRICAL
Port_2041625_1 | CABLE | ELECTRICAL
Port_2041645_1 | CABLE | ELECTRICAL
Port_2041659_1 | CABLE | ELECTRICAL
Port_2041669_1 | CABLE | ELECTRICAL
Port_2041679_1 | CABLE | ELECTRICAL
Port_2041693_1 | CABLE | ELECTRICAL
Port_2041707_1 | CABLE | ELECTRICAL
Port_2041776_1 | CABLE | ELECTRICAL
Port_2041791_1 | CABLE | ELECTRICAL
Port_2041813_1 | CABLE | ELECTRICAL
Port_2041823_1 | CABLE | ELECTRICAL
Port_2041837_1 | CABLE | ELECTRICAL
Port_2041855_1 | CABLE | ELECTRICAL
Port_2041869_1 | CABLE | ELECTRICAL
Port_2041887_1 | CABLE | ELECTRICAL
Port_2041899_1 | CABLE | ELECTRICAL
Port_2041907_1 | CABLE | ELECTRICAL
Port_2041917_1 | CABLE | ELECTRICAL
Port_2041935_1 | CABLE | ELECTRICAL
Port_2041947_1 | CABLE | ELECTRICAL
Port_2041965_1 | CABLE | ELECTRICAL
Port_2041979_1 | CABLE | ELECTRICAL
Port_2041989_1 | CABLE | ELECTRICAL
Port_2042001_1 | CABLE | ELECTRICAL
Port_2042021_1 | CABLE | ELECTRICAL
Port_2042039_1 | CABLE | ELECTRICAL
Port_2042049_1 | CABLE | ELECTRICAL
Port_2042061_1 | CABLE | ELECTRICAL
Port_2042077_1 | CABLE | ELECTRICAL
Port_2042095_1 | CABLE | ELECTRICAL
Port_2042661_1 | CABLE | ELECTRICAL
Port_2042710_1 | CABLE | ELECTRICAL
Port_2042773_1 | CABLE | ELECTRICAL
Port_2042783_1 | CABLE | ELECTRICAL
Port_2042796_1 | CABLE | ELECTRICAL
Port_2042816_1 | CABLE | ELECTRICAL
Port_2042830_1 | CABLE | ELECTRICAL
Port_2042850_1 | CABLE | ELECTRICAL
Port_2042866_1 | CABLE | ELECTRICAL
Port_2042882_1 | CABLE | ELECTRICAL
Port_2042894_1 | CABLE | ELECTRICAL
Port_2043018_1 | CABLE | ELECTRICAL
Port_2043038_1 | CABLE | ELECTRICAL
Port_2043054_1 | CABLE | ELECTRICAL
Port_2043070_1 | CABLE | ELECTRICAL
Port_2043092_1 | CABLE | ELECTRICAL
Port_2043142_1 | CABLE | ELECTRICAL
Port_2043172_1 | CABLE | ELECTRICAL
Port_2043196_1 | CABLE | ELECTRICAL
Port_2043251_1 | CABLE | ELECTRICAL
Port_2043263_1 | CABLE | ELECTRICAL
Port_2043280_1 | CABLE | ELECTRICAL
Port_2043298_1 | CABLE | ELECTRICAL
Port_2043316_1 | CABLE | ELECTRICAL
Port_2043330_1 | CABLE | ELECTRICAL
Port_2043350_1 | CABLE | ELECTRICAL
Port_2043366_1 | CABLE | ELECTRICAL
Port_2043380_1 | CABLE | ELECTRICAL
Port_2043390_1 | CABLE | ELECTRICAL
Port_2043398_1 | CABLE | ELECTRICAL
Port_2043414_1 | CABLE | ELECTRICAL
Port_2043424_1 | CABLE | ELECTRICAL
Port_2043438_1 | CABLE | ELECTRICAL
Port_2043448_1 | CABLE | ELECTRICAL
Port_2043458_1 | CABLE | ELECTRICAL
Port_2043472_1 | CABLE | ELECTRICAL
Port_2043482_1 | CABLE | ELECTRICAL
Port_2043498_1 | CABLE | ELECTRICAL
Port_2043516_1 | CABLE | ELECTRICAL
Port_2043524_1 | CABLE | ELECTRICAL
Port_2043532_1 | CABLE | ELECTRICAL
Port_2043546_1 | CABLE | ELECTRICAL
Port_2043560_1 | CABLE | ELECTRICAL
Port_2043942_1 | CABLE | ELECTRICAL
Port_2043960_1 | CABLE | ELECTRICAL
Port_2043980_1 | CABLE | ELECTRICAL
Port_2043998_1 | CABLE | ELECTRICAL
Port_2044006_1 | CABLE | ELECTRICAL
Port_2045519_0 | CABLECARRIER | CONVEYING
Port_2305995_2 | CABLECARRIER | CONVEYING
Port_2045519_1 | CABLECARRIER | CONVEYING
Port_2047128_0 | CABLECARRIER | CONVEYING
Port_2309591_1 | CABLECARRIER | CONVEYING
Port_2047128_1 | CABLECARRIER | CONVEYING
Port_2304476_2 | CABLECARRIER | CONVEYING
Port_2047133_0 | CABLECARRIER | CONVEYING
Port_2309589_1 | CABLECARRIER | CONVEYING
Port_2047133_1 | CABLECARRIER | CONVEYING
Port_2309563_2 | CABLECARRIER | CONVEYING
Port_2047134_0 | CABLECARRIER | CONVEYING
Port_2309562_1 | CABLECARRIER | CONVEYING
Port_2047134_1 | CABLECARRIER | CONVEYING
Port_2047137_2 | CABLECARRIER | CONVEYING
Port_2047136_0 | CABLECARRIER | CONVEYING
Port_2047137_1 | CABLECARRIER | CONVEYING
Port_2047136_1 | CABLECARRIER | CONVEYING
Port_2047149_0 | CABLECARRIER | CONVEYING
Port_2047152_1 | CABLECARRIER | CONVEYING
Port_2047149_1 | CABLECARRIER | CONVEYING
Port_2304453_2 | CABLECARRIER | CONVEYING
Port_2047151_0 | CABLECARRIER | CONVEYING
Port_2047152_2 | CABLECARRIER | CONVEYING
Port_2047151_1 | CABLECARRIER | CONVEYING
Port_2047169_0 | CABLECARRIER | CONVEYING
Port_2310856_1 | CABLECARRIER | CONVEYING
Port_2047169_1 | CABLECARRIER | CONVEYING
Port_2334976_1 | CABLECARRIER | CONVEYING
Port_2047171_0 | CABLECARRIER | CONVEYING
Port_2310019_2 | CABLECARRIER | CONVEYING
Port_2047171_1 | CABLECARRIER | CONVEYING
Port_2053025_5 | CABLECARRIER | CONVEYING
Port_2047174_0 | CABLECARRIER | CONVEYING
Port_2309919_2 | CABLECARRIER | CONVEYING
Port_2047174_1 | CABLECARRIER | CONVEYING
Port_2310019_1 | CABLECARRIER | CONVEYING
Port_2047175_0 | CABLECARRIER | CONVEYING
Port_2309781_2 | CABLECARRIER | CONVEYING
Port_2047175_1 | CABLECARRIER | CONVEYING
Port_2047178_1 | CABLECARRIER | CONVEYING
Port_2047177_0 | CABLECARRIER | CONVEYING
Port_2047178_2 | CABLECARRIER | CONVEYING
Port_2047177_1 | CABLECARRIER | CONVEYING
Port_2047192_0 | CABLECARRIER | CONVEYING
Port_2332714_2 | CABLECARRIER | CONVEYING
Port_2047192_1 | CABLECARRIER | CONVEYING
Port_2310898_1 | CABLECARRIER | CONVEYING
Port_2047194_0 | CABLECARRIER | CONVEYING
Port_2332714_1 | CABLECARRIER | CONVEYING
Port_2047194_1 | CABLECARRIER | CONVEYING
Port_2053024_13 | CABLECARRIER | CONVEYING
Port_2047207_0 | CABLECARRIER | CONVEYING
Port_2309563_1 | CABLECARRIER | CONVEYING
Port_2047207_1 | CABLECARRIER | CONVEYING
Port_2047458_0 | CABLECARRIER | CONVEYING
Port_2053025_10 | CABLECARRIER | CONVEYING
Port_2047458_1 | CABLECARRIER | CONVEYING
Port_2332280_1 | CABLECARRIER | CONVEYING
Port_2047462_0 | CABLECARRIER | CONVEYING
Port_2305362_1 | CABLECARRIER | CONVEYING
Port_2047462_1 | CABLECARRIER | CONVEYING
Port_2287816_2 | CABLECARRIER | CONVEYING
Port_2047464_0 | CABLECARRIER | CONVEYING
Port_2287777_1 | CABLECARRIER | CONVEYING
Port_2047464_1 | CABLECARRIER | CONVEYING
Port_2047477_0 | CABLECARRIER | CONVEYING
Port_2288890_2 | CABLECARRIER | CONVEYING
Port_2047477_1 | CABLECARRIER | CONVEYING
Port_2324686_1 | CABLECARRIER | CONVEYING
Port_2047486_0 | CABLECARRIER | CONVEYING
Port_2047488_1 | CABLECARRIER | CONVEYING
Port_2047486_1 | CABLECARRIER | CONVEYING
Port_2047487_0 | CABLECARRIER | CONVEYING
Port_2047488_2 | CABLECARRIER | CONVEYING
Port_2047487_1 | CABLECARRIER | CONVEYING
Port_2290809_2 | CABLECARRIER | CONVEYING
Port_2047489_0 | CABLECARRIER | CONVEYING
Port_2290809_1 | CABLECARRIER | CONVEYING
Port_2047489_1 | CABLECARRIER | CONVEYING
Port_2302967_2 | CABLECARRIER | CONVEYING
Port_2047503_0 | CABLECARRIER | CONVEYING
Port_2329641_2 | CABLECARRIER | CONVEYING
Port_2047503_1 | CABLECARRIER | CONVEYING
Port_2329882_1 | CABLECARRIER | CONVEYING
Port_2047505_0 | CABLECARRIER | CONVEYING
Port_2328618_2 | CABLECARRIER | CONVEYING
Port_2047505_1 | CABLECARRIER | CONVEYING
Port_2047509_0 | CABLECARRIER | CONVEYING
Port_2047511_1 | CABLECARRIER | CONVEYING
Port_2047509_1 | CABLECARRIER | CONVEYING
Port_2047510_0 | CABLECARRIER | CONVEYING
Port_2047511_2 | CABLECARRIER | CONVEYING
Port_2047510_1 | CABLECARRIER | CONVEYING
Port_2290767_2 | CABLECARRIER | CONVEYING
Port_2047512_0 | CABLECARRIER | CONVEYING
Port_2290767_1 | CABLECARRIER | CONVEYING
Port_2047512_1 | CABLECARRIER | CONVEYING
Port_2304012_2 | CABLECARRIER | CONVEYING
Port_2052945_0 | CABLECARRIER | CONVEYING
Port_2311165_1 | CABLECARRIER | CONVEYING
Port_2052945_1 | CABLECARRIER | CONVEYING
Port_2052955_0 | CABLECARRIER | CONVEYING
Port_2312286_1 | CABLECARRIER | CONVEYING
Port_2052955_1 | CABLECARRIER | CONVEYING
Port_2311165_2 | CABLECARRIER | CONVEYING
Port_2052960_0 | CABLECARRIER | CONVEYING
Port_2312284_1 | CABLECARRIER | CONVEYING
Port_2052960_1 | CABLECARRIER | CONVEYING
Port_2312258_2 | CABLECARRIER | CONVEYING
Port_2052961_0 | CABLECARRIER | CONVEYING
Port_2312257_1 | CABLECARRIER | CONVEYING
Port_2052961_1 | CABLECARRIER | CONVEYING
Port_2052964_2 | CABLECARRIER | CONVEYING
Port_2052963_0 | CABLECARRIER | CONVEYING
Port_2052964_1 | CABLECARRIER | CONVEYING
Port_2052963_1 | CABLECARRIER | CONVEYING
Port_2052966_0 | CABLECARRIER | CONVEYING
Port_2311134_1 | CABLECARRIER | CONVEYING
Port_2052966_1 | CABLECARRIER | CONVEYING
Port_2052976_0 | CABLECARRIER | CONVEYING
Port_2311133_1 | CABLECARRIER | CONVEYING
Port_2052976_1 | CABLECARRIER | CONVEYING
Port_2311134_2 | CABLECARRIER | CONVEYING
Port_2052978_0 | CABLECARRIER | CONVEYING
Port_2311133_2 | CABLECARRIER | CONVEYING
Port_2052978_1 | CABLECARRIER | CONVEYING
Port_2052984_0 | CABLECARRIER | CONVEYING
Port_2052986_1 | CABLECARRIER | CONVEYING
Port_2052984_1 | CABLECARRIER | CONVEYING
Port_2052985_0 | CABLECARRIER | CONVEYING
Port_2052986_2 | CABLECARRIER | CONVEYING
Port_2052985_1 | CABLECARRIER | CONVEYING
Port_2311988_2 | CABLECARRIER | CONVEYING
Port_2052995_0 | CABLECARRIER | CONVEYING
Port_2336331_1 | CABLECARRIER | CONVEYING
Port_2052995_1 | CABLECARRIER | CONVEYING
Port_2311988_1 | CABLECARRIER | CONVEYING
Port_2052997_0 | CABLECARRIER | CONVEYING
Port_2311860_2 | CABLECARRIER | CONVEYING
Port_2052997_1 | CABLECARRIER | CONVEYING
Port_2053000_0 | CABLECARRIER | CONVEYING
Port_2311813_2 | CABLECARRIER | CONVEYING
Port_2053000_1 | CABLECARRIER | CONVEYING
Port_2311860_1 | CABLECARRIER | CONVEYING
Port_2053001_0 | CABLECARRIER | CONVEYING
Port_2311675_2 | CABLECARRIER | CONVEYING
Port_2053001_1 | CABLECARRIER | CONVEYING
Port_2053004_1 | CABLECARRIER | CONVEYING
Port_2053003_0 | CABLECARRIER | CONVEYING
Port_2053004_2 | CABLECARRIER | CONVEYING
Port_2053003_1 | CABLECARRIER | CONVEYING
Port_2053007_0 | CABLECARRIER | CONVEYING
Port_2053009_1 | CABLECARRIER | CONVEYING
Port_2053007_1 | CABLECARRIER | CONVEYING
Port_2053008_0 | CABLECARRIER | CONVEYING
Port_2053009_2 | CABLECARRIER | CONVEYING
Port_2053008_1 | CABLECARRIER | CONVEYING
Port_2311952_2 | CABLECARRIER | CONVEYING
Port_2053018_0 | CABLECARRIER | CONVEYING
Port_2311951_2 | CABLECARRIER | CONVEYING
Port_2053018_1 | CABLECARRIER | CONVEYING
Port_2311952_1 | CABLECARRIER | CONVEYING
Port_2053020_0 | CABLECARRIER | CONVEYING
Port_2311951_1 | CABLECARRIER | CONVEYING
Port_2053020_1 | CABLECARRIER | CONVEYING
Port_2053024_0 | CABLECARRIER | CONVEYING
Port_2053024_1 | CABLECARRIER | CONVEYING
Port_2053024_10 | CABLECARRIER | CONVEYING
Port_2299926_1 | CABLECARRIER | CONVEYING
Port_2053024_12 | CABLECARRIER | CONVEYING
Port_2233286_1 | CABLECARRIER | CONVEYING
Port_2053024_14 | CABLECARRIER | CONVEYING
Port_2310504_0 | CABLECARRIER | CONVEYING
Port_2053024_17 | CABLECARRIER | CONVEYING
Port_2338470_1 | CABLECARRIER | CONVEYING
Port_2053024_18 | CABLECARRIER | CONVEYING
Port_2291655_0 | CABLECARRIER | CONVEYING
Port_2053025_0 | CABLECARRIER | CONVEYING
Port_2053025_1 | CABLECARRIER | CONVEYING
Port_2053025_6 | CABLECARRIER | CONVEYING
Port_2311429_0 | CABLECARRIER | CONVEYING
Port_2053025_7 | CABLECARRIER | CONVEYING
Port_2233176_1 | CABLECARRIER | CONVEYING
Port_2053025_8 | CABLECARRIER | CONVEYING
Port_2261451_1 | CABLECARRIER | CONVEYING
Port_2053025_9 | CABLECARRIER | CONVEYING
Port_2331668_0 | CABLECARRIER | CONVEYING
Port_2053945_1 | CABLE | ELECTRICAL
Port_2054025_1 | CABLE | ELECTRICAL
Port_2054043_1 | CABLE | ELECTRICAL
Port_2054317_1 | CABLE | ELECTRICAL
Port_2054333_1 | CABLE | ELECTRICAL
Port_2054345_1 | CABLE | ELECTRICAL
Port_2054359_1 | CABLE | ELECTRICAL
Port_2054367_1 | CABLE | ELECTRICAL
Port_2054395_1 | CABLE | ELECTRICAL
Port_2054405_1 | CABLE | ELECTRICAL
Port_2054413_1 | CABLE | ELECTRICAL
Port_2054421_1 | CABLE | ELECTRICAL
Port_2068536_1 | CABLE | ELECTRICAL
Port_2068555_1 | CABLE | ELECTRICAL
Port_2068569_1 | CABLE | ELECTRICAL
Port_2068579_1 | CABLE | ELECTRICAL
Port_2094207_1 | CABLE | ELECTRICAL
Port_2094262_1 | CABLE | ELECTRICAL
Port_2094571_1 | CABLE | ELECTRICAL
Port_2094585_1 | CABLE | ELECTRICAL
Port_2094601_1 | CABLE | ELECTRICAL
Port_2094615_1 | CABLE | ELECTRICAL
Port_2094627_1 | CABLE | ELECTRICAL
Port_2094635_1 | CABLE | ELECTRICAL
Port_2094651_1 | CABLE | ELECTRICAL
Port_2094665_1 | CABLE | ELECTRICAL
Port_2094673_1 | CABLE | ELECTRICAL
Port_2094685_1 | CABLE | ELECTRICAL
Port_2094695_1 | CABLE | ELECTRICAL
Port_2094707_1 | CABLE | ELECTRICAL
Port_2094715_1 | CABLE | ELECTRICAL
Port_2094727_1 | CABLE | ELECTRICAL
Port_2094739_1 | CABLE | ELECTRICAL
Port_2094753_1 | CABLE | ELECTRICAL
Port_2094763_1 | CABLE | ELECTRICAL
Port_2094771_1 | CABLE | ELECTRICAL
Port_2094781_1 | CABLE | ELECTRICAL
Port_2094791_1 | CABLE | ELECTRICAL
Port_2094799_1 | CABLE | ELECTRICAL
Port_2094807_1 | CABLE | ELECTRICAL
Port_2094817_1 | CABLE | ELECTRICAL
Port_2094827_1 | CABLE | ELECTRICAL
Port_2094849_1 | CABLE | ELECTRICAL
Port_2095092_1 | CABLE | ELECTRICAL
Port_2095104_1 | CABLE | ELECTRICAL
Port_2095114_1 | CABLE | ELECTRICAL
Port_2095122_1 | CABLE | ELECTRICAL
Port_2095136_1 | CABLE | ELECTRICAL
Port_2095150_1 | CABLE | ELECTRICAL
Port_2095158_1 | CABLE | ELECTRICAL
Port_2095166_1 | CABLE | ELECTRICAL
Port_2095174_1 | CABLE | ELECTRICAL
Port_2095182_1 | CABLE | ELECTRICAL
Port_2095192_1 | CABLE | ELECTRICAL
Port_2095202_1 | CABLE | ELECTRICAL
Port_2095218_1 | CABLE | ELECTRICAL
Port_2095226_1 | CABLE | ELECTRICAL
Port_2095236_1 | CABLE | ELECTRICAL
Port_2095248_1 | CABLE | ELECTRICAL
Port_2095260_1 | CABLE | ELECTRICAL
Port_2095268_1 | CABLE | ELECTRICAL
Port_2095280_1 | CABLE | ELECTRICAL
Port_2095292_1 | CABLE | ELECTRICAL
Port_2095300_1 | CABLE | ELECTRICAL
Port_2095314_1 | CABLE | ELECTRICAL
Port_2095324_1 | CABLE | ELECTRICAL
Port_2095334_1 | CABLE | ELECTRICAL
Port_2103698_1 | CABLE | ELECTRICAL
Port_2103737_1 | CABLE | ELECTRICAL
Port_2103791_1 | CABLE | ELECTRICAL
Port_2103912_1 | CABLE | ELECTRICAL
Port_2103943_1 | CABLE | ELECTRICAL
Port_2103998_1 | CABLE | ELECTRICAL
Port_2104020_1 | CABLE | ELECTRICAL
Port_2104090_1 | CABLE | ELECTRICAL
Port_2104101_1 | CABLE | ELECTRICAL
Port_2104114_1 | CABLE | ELECTRICAL
Port_2104129_1 | CABLE | ELECTRICAL
Port_2104175_1 | CABLE | ELECTRICAL
Port_2104186_1 | CABLE | ELECTRICAL
Port_2104269_1 | CABLE | ELECTRICAL
Port_2104294_1 | CABLE | ELECTRICAL
Port_2104349_1 | CABLE | ELECTRICAL
Port_2104360_1 | CABLE | ELECTRICAL
Port_2104382_1 | CABLE | ELECTRICAL
Port_2104392_1 | CABLE | ELECTRICAL
Port_2104436_1 | CABLE | ELECTRICAL
Port_2107629_1 | CABLE | ELECTRICAL
Port_2107693_1 | CABLE | ELECTRICAL
Port_2107770_1 | CABLE | ELECTRICAL
Port_2107790_1 | CABLE | ELECTRICAL
Port_2107870_1 | CABLE | ELECTRICAL
Port_2107898_1 | CABLE | ELECTRICAL
Port_2107908_1 | CABLE | ELECTRICAL
Port_2107934_1 | CABLE | ELECTRICAL
Port_2108019_1 | CABLE | ELECTRICAL
Port_2108035_1 | CABLE | ELECTRICAL
Port_2108064_1 | CABLE | ELECTRICAL
Port_2108162_1 | CABLE | ELECTRICAL
Port_2108182_1 | CABLE | ELECTRICAL
Port_2108242_1 | CABLE | ELECTRICAL
Port_2109920_1 | CABLE | ELECTRICAL
Port_2109983_1 | CABLE | ELECTRICAL
Port_2110165_1 | CABLE | ELECTRICAL
Port_2110210_1 | CABLE | ELECTRICAL
Port_2110257_1 | CABLE | ELECTRICAL
Port_2110267_1 | CABLE | ELECTRICAL
Port_2110425_1 | CABLE | ELECTRICAL
Port_2111045_1 | CABLE | ELECTRICAL
Port_2111061_1 | CABLE | ELECTRICAL
Port_2111083_1 | CABLE | ELECTRICAL
Port_2111232_1 | CABLE | ELECTRICAL
Port_2111313_1 | CABLE | ELECTRICAL
Port_2111447_1 | CABLE | ELECTRICAL
Port_2115491_1 | CABLE | ELECTRICAL
Port_2115936_1 | CABLE | ELECTRICAL
Port_2115944_1 | CABLE | ELECTRICAL
Port_2115952_1 | CABLE | ELECTRICAL
Port_2115960_1 | CABLE | ELECTRICAL
Port_2115970_1 | CABLE | ELECTRICAL
Port_2115980_1 | CABLE | ELECTRICAL
Port_2115988_1 | CABLE | ELECTRICAL
Port_2115996_1 | CABLE | ELECTRICAL
Port_2116004_1 | CABLE | ELECTRICAL
Port_2116012_1 | CABLE | ELECTRICAL
Port_2118024_1 | CABLE | ELECTRICAL
Port_2118091_1 | CABLE | ELECTRICAL
Port_2132782_1 | CABLE | ELECTRICAL
Port_2135098_1 | CABLE | ELECTRICAL
Port_2140047_1 | CABLE | ELECTRICAL
Port_2178382_1 | CABLE | ELECTRICAL
Port_2179103_1 | CABLE | ELECTRICAL
Port_2179954_1 | CABLE | ELECTRICAL
Port_2180056_1 | CABLE | ELECTRICAL
Port_2186268_1 | CABLE | ELECTRICAL
Port_2186338_1 | CABLE | ELECTRICAL
Port_2186974_1 | CABLE | ELECTRICAL
Port_2187288_1 | CABLE | ELECTRICAL
Port_2188150_1 | CABLE | ELECTRICAL
Port_2188415_1 | CABLE | ELECTRICAL
Port_2189306_1 | CABLE | ELECTRICAL
Port_2192156_1 | CABLE | ELECTRICAL
Port_2193436_1 | CABLE | ELECTRICAL
Port_2193713_1 | CABLE | ELECTRICAL
Port_2193938_1 | CABLE | ELECTRICAL
Port_2194223_1 | CABLE | ELECTRICAL
Port_2194429_1 | CABLE | ELECTRICAL
Port_2194532_1 | CABLE | ELECTRICAL
Port_2194596_1 | CABLE | ELECTRICAL
Port_2194670_1 | CABLE | ELECTRICAL
Port_2195088_1 | CABLE | ELECTRICAL
Port_2196896_1 | CABLE | ELECTRICAL
Port_2196932_1 | CABLE | ELECTRICAL
Port_2233163_0 | CABLECARRIER | CONVEYING
Port_2233165_1 | CABLECARRIER | CONVEYING
Port_2233163_1 | CABLECARRIER | CONVEYING
Port_2233164_0 | CABLECARRIER | CONVEYING
Port_2233165_2 | CABLECARRIER | CONVEYING
Port_2233164_1 | CABLECARRIER | CONVEYING
Port_2424703_2 | CABLECARRIER | CONVEYING
Port_2233166_0 | CABLECARRIER | CONVEYING
Port_2424735_2 | CABLECARRIER | CONVEYING
Port_2233166_1 | CABLECARRIER | CONVEYING
Port_2424736_2 | CABLECARRIER | CONVEYING
Port_2233176_0 | CABLECARRIER | CONVEYING
Port_2312799_2 | CABLECARRIER | CONVEYING
Port_2233179_0 | CABLECARRIER | CONVEYING
Port_2312515_2 | CABLECARRIER | CONVEYING
Port_2233179_1 | CABLECARRIER | CONVEYING
Port_2312799_1 | CABLECARRIER | CONVEYING
Port_2233180_0 | CABLECARRIER | CONVEYING
Port_2294505_2 | CABLECARRIER | CONVEYING
Port_2233180_1 | CABLECARRIER | CONVEYING
Port_2233183_1 | CABLECARRIER | CONVEYING
Port_2233182_0 | CABLECARRIER | CONVEYING
Port_2233183_2 | CABLECARRIER | CONVEYING
Port_2233182_1 | CABLECARRIER | CONVEYING
Port_2233269_0 | CABLECARRIER | CONVEYING
Port_2233269_1 | CABLECARRIER | CONVEYING
Port_2233271_1 | CABLECARRIER | CONVEYING
Port_2233270_0 | CABLECARRIER | CONVEYING
Port_2233271_2 | CABLECARRIER | CONVEYING
Port_2233270_1 | CABLECARRIER | CONVEYING
Port_2233273_2 | CABLECARRIER | CONVEYING
Port_2233272_0 | CABLECARRIER | CONVEYING
Port_2233273_1 | CABLECARRIER | CONVEYING
Port_2233272_1 | CABLECARRIER | CONVEYING
Port_2294347_2 | CABLECARRIER | CONVEYING
Port_2233286_0 | CABLECARRIER | CONVEYING
Port_2294347_1 | CABLECARRIER | CONVEYING
Port_2235349_1 | CABLE | ELECTRICAL
Port_2235472_1 | CABLE | ELECTRICAL
Port_2235519_1 | CABLE | ELECTRICAL
Port_2235552_1 | CABLE | ELECTRICAL
Port_2235579_1 | CABLE | ELECTRICAL
Port_2235694_1 | CABLE | ELECTRICAL
Port_2235729_1 | CABLE | ELECTRICAL
Port_2235763_1 | CABLE | ELECTRICAL
Port_2235791_1 | CABLE | ELECTRICAL
Port_2239111_1 | CABLE | ELECTRICAL
Port_2239253_1 | CABLE | ELECTRICAL
Port_2242380_3 | CABLE | ELECTRICAL
Port_2242380_4 | CABLE | ELECTRICAL
Port_2242380_5 | CABLE | ELECTRICAL
Port_2242380_6 | CABLE | ELECTRICAL
Port_2242380_7 | CABLE | ELECTRICAL
Port_2242900_3 | CABLE | ELECTRICAL
Port_2242900_4 | CABLE | ELECTRICAL
Port_2242900_5 | CABLE | ELECTRICAL
Port_2242900_6 | CABLE | ELECTRICAL
Port_2242900_7 | CABLE | ELECTRICAL
Port_2243047_3 | CABLE | ELECTRICAL
Port_2243047_4 | CABLE | ELECTRICAL
Port_2243047_5 | CABLE | ELECTRICAL
Port_2243047_6 | CABLE | ELECTRICAL
Port_2243047_7 | CABLE | ELECTRICAL
Port_2247183_1 | CABLE | ELECTRICAL
Port_2247680_1 | CABLE | ELECTRICAL
Port_2248306_1 | CABLE | ELECTRICAL
Port_2248927_1 | CABLE | ELECTRICAL
Port_2259677_0 | CABLECARRIER | CONVEYING
Port_2259677_1 | CABLECARRIER | CONVEYING
Port_2259679_0 | CABLECARRIER | CONVEYING
Port_2259679_1 | CABLECARRIER | CONVEYING
Port_2259681_0 | CABLECARRIER | CONVEYING
Port_2259681_1 | CABLECARRIER | CONVEYING
Port_2261451_0 | CABLECARRIER | CONVEYING
Port_2323993_2 | CABLECARRIER | CONVEYING
Port_2262505_0 | CABLECARRIER | CONVEYING
Port_2300908_2 | CABLECARRIER | CONVEYING
Port_2262505_1 | CABLECARRIER | CONVEYING
Port_2301215_2 | CABLECARRIER | CONVEYING
Port_2277238_0 | CABLECARRIER | CONVEYING
Port_2423870_1 | CABLECARRIER | CONVEYING
Port_2277238_1 | CABLECARRIER | CONVEYING
Port_2302122_3 | CABLECARRIER | CONVEYING
Port_2287330_1 | CABLE | ELECTRICAL
Port_2287531_0 | CABLECARRIER | CONVEYING
Port_2287777_2 | CABLECARRIER | CONVEYING
Port_2287531_1 | CABLECARRIER | CONVEYING
Port_2287778_2 | CABLECARRIER | CONVEYING
Port_2287767_0 | CABLECARRIER | CONVEYING
Port_2287768_2 | CABLECARRIER | CONVEYING
Port_2287767_1 | CABLECARRIER | CONVEYING
Port_2287778_1 | CABLECARRIER | CONVEYING
Port_2287768_1 | CABLECARRIER | CONVEYING
Port_2287809_0 | CABLECARRIER | CONVEYING
Port_2287809_1 | CABLECARRIER | CONVEYING
Port_2287811_1 | CABLECARRIER | CONVEYING
Port_2287810_0 | CABLECARRIER | CONVEYING
Port_2287811_2 | CABLECARRIER | CONVEYING
Port_2287810_1 | CABLECARRIER | CONVEYING
Port_2287816_1 | CABLECARRIER | CONVEYING
Port_2288879_0 | CABLECARRIER | CONVEYING
Port_2288890_1 | CABLECARRIER | CONVEYING
Port_2288879_1 | CABLECARRIER | CONVEYING
Port_2288910_0 | CABLECARRIER | CONVEYING
Port_2289001_1 | CABLECARRIER | CONVEYING
Port_2288910_1 | CABLECARRIER | CONVEYING
Port_2289001_2 | CABLECARRIER | CONVEYING
Port_2325191_0 | CABLECARRIER | CONVEYING
Port_2290430_1 | CABLECARRIER | CONVEYING
Port_2290469_0 | CABLECARRIER | CONVEYING
Port_2290475_1 | CABLECARRIER | CONVEYING
Port_2290469_1 | CABLECARRIER | CONVEYING
Port_2290495_0 | CABLECARRIER | CONVEYING
Port_2290503_1 | CABLECARRIER | CONVEYING
Port_2290495_1 | CABLECARRIER | CONVEYING
Port_2291041_1 | CABLE | ELECTRICAL
Port_2291655_1 | CABLECARRIER | CONVEYING
Port_2444429_2 | CABLECARRIER | CONVEYING
Port_2294504_0 | CABLECARRIER | CONVEYING
Port_2424735_1 | CABLECARRIER | CONVEYING
Port_2294504_1 | CABLECARRIER | CONVEYING
Port_2312515_3 | CABLECARRIER | CONVEYING
Port_2294505_1 | CABLECARRIER | CONVEYING
Port_2312516_0 | CABLECARRIER | CONVEYING
Port_2297964_1 | CABLE | ELECTRICAL
Port_2297965_1 | CABLE | ELECTRICAL
Port_2298298_1 | CABLE | ELECTRICAL
Port_2298334_1 | CABLE | ELECTRICAL
Port_2298506_1 | CABLE | ELECTRICAL
Port_2298507_1 | CABLE | ELECTRICAL
Port_2299926_0 | CABLECARRIER | CONVEYING
Port_2304012_1 | CABLECARRIER | CONVEYING
Port_2300340_0 | CABLECARRIER | CONVEYING
Port_2323862_1 | CABLECARRIER | CONVEYING
Port_2300340_1 | CABLECARRIER | CONVEYING
Port_2300902_0 | CABLECARRIER | CONVEYING
Port_2300908_3 | CABLECARRIER | CONVEYING
Port_2300902_1 | CABLECARRIER | CONVEYING
Port_2300908_1 | CABLECARRIER | CONVEYING
Port_2424038_0 | CABLECARRIER | CONVEYING
Port_2300963_0 | CABLECARRIER | CONVEYING
Port_2424037_3 | CABLECARRIER | CONVEYING
Port_2300963_1 | CABLECARRIER | CONVEYING
Port_2301107_0 | CABLECARRIER | CONVEYING
Port_2424037_1 | CABLECARRIER | CONVEYING
Port_2301107_1 | CABLECARRIER | CONVEYING
Port_2423870_2 | CABLECARRIER | CONVEYING
Port_2301190_0 | CABLECARRIER | CONVEYING
Port_2301215_1 | CABLECARRIER | CONVEYING
Port_2301190_1 | CABLECARRIER | CONVEYING
Port_2302122_1 | CABLECARRIER | CONVEYING
Port_2302123_0 | CABLECARRIER | CONVEYING
Port_2302123_1 | CABLECARRIER | CONVEYING
Port_2302822_0 | CABLECARRIER | CONVEYING
Port_2302964_2 | CABLECARRIER | CONVEYING
Port_2302822_1 | CABLECARRIER | CONVEYING
Port_2331675_1 | CABLECARRIER | CONVEYING
Port_2302823_0 | CABLECARRIER | CONVEYING
Port_2302967_1 | CABLECARRIER | CONVEYING
Port_2302823_1 | CABLECARRIER | CONVEYING
Port_2331510_1 | CABLECARRIER | CONVEYING
Port_2302964_1 | CABLECARRIER | CONVEYING
Port_2327158_1 | CABLECARRIER | CONVEYING
Port_2302964_3 | CABLECARRIER | CONVEYING
Port_2331246_0 | CABLECARRIER | CONVEYING
Port_2302965_0 | CABLECARRIER | CONVEYING
Port_2329641_1 | CABLECARRIER | CONVEYING
Port_2302965_1 | CABLECARRIER | CONVEYING
Port_2329642_2 | CABLECARRIER | CONVEYING
Port_2303325_0 | CABLECARRIER | CONVEYING
Port_2325352_2 | CABLECARRIER | CONVEYING
Port_2303325_1 | CABLECARRIER | CONVEYING
Port_2305389_3 | CABLECARRIER | CONVEYING
Port_2304445_0 | CABLECARRIER | CONVEYING
Port_2304453_1 | CABLECARRIER | CONVEYING
Port_2304445_1 | CABLECARRIER | CONVEYING
Port_2304470_0 | CABLECARRIER | CONVEYING
Port_2304476_1 | CABLECARRIER | CONVEYING
Port_2304470_1 | CABLECARRIER | CONVEYING
Port_2304854_0 | CABLECARRIER | CONVEYING
Port_2309591_2 | CABLECARRIER | CONVEYING
Port_2304854_1 | CABLECARRIER | CONVEYING
Port_2309589_3 | CABLECARRIER | CONVEYING
Port_2305291_0 | CABLECARRIER | CONVEYING
Port_2305389_1 | CABLECARRIER | CONVEYING
Port_2305291_1 | CABLECARRIER | CONVEYING
Port_2332251_2 | CABLECARRIER | CONVEYING
Port_2305362_2 | CABLECARRIER | CONVEYING
Port_2305390_0 | CABLECARRIER | CONVEYING
Port_2305389_2 | CABLECARRIER | CONVEYING
Port_2305390_1 | CABLECARRIER | CONVEYING
Port_2305779_0 | CABLECARRIER | CONVEYING
Port_2306344_2 | CABLECARRIER | CONVEYING
Port_2305779_1 | CABLECARRIER | CONVEYING
Port_2306342_3 | CABLECARRIER | CONVEYING
Port_2305781_2 | CABLECARRIER | CONVEYING
Port_2306343_0 | CABLECARRIER | CONVEYING
Port_2305869_0 | CABLECARRIER | CONVEYING
Port_2305995_1 | CABLECARRIER | CONVEYING
Port_2305869_1 | CABLECARRIER | CONVEYING
Port_2305996_2 | CABLECARRIER | CONVEYING
Port_2305880_0 | CABLECARRIER | CONVEYING
Port_2305996_1 | CABLECARRIER | CONVEYING
Port_2305880_1 | CABLECARRIER | CONVEYING
Port_2306128_0 | CABLECARRIER | CONVEYING
Port_2306344_1 | CABLECARRIER | CONVEYING
Port_2306128_1 | CABLECARRIER | CONVEYING
Port_2306141_2 | CABLECARRIER | CONVEYING
Port_2306135_0 | CABLECARRIER | CONVEYING
Port_2306141_1 | CABLECARRIER | CONVEYING
Port_2306135_1 | CABLECARRIER | CONVEYING
Port_2306342_2 | CABLECARRIER | CONVEYING
Port_2306343_1 | CABLECARRIER | CONVEYING
Port_2306974_0 | CABLECARRIER | CONVEYING
Port_2306980_2 | CABLECARRIER | CONVEYING
Port_2306974_1 | CABLECARRIER | CONVEYING
Port_2307003_1 | CABLECARRIER | CONVEYING
Port_2307004_1 | CABLECARRIER | CONVEYING
Port_2308194_2 | CABLECARRIER | CONVEYING
Port_2335701_0 | CABLECARRIER | CONVEYING
Port_2309562_2 | CABLECARRIER | CONVEYING
Port_2309590_0 | CABLECARRIER | CONVEYING
Port_2309589_2 | CABLECARRIER | CONVEYING
Port_2309590_1 | CABLECARRIER | CONVEYING
Port_2309780_0 | CABLECARRIER | CONVEYING
Port_2335331_1 | CABLECARRIER | CONVEYING
Port_2309780_1 | CABLECARRIER | CONVEYING
Port_2309919_3 | CABLECARRIER | CONVEYING
Port_2309781_1 | CABLECARRIER | CONVEYING
Port_2309920_0 | CABLECARRIER | CONVEYING
Port_2309919_1 | CABLECARRIER | CONVEYING
Port_2309920_1 | CABLECARRIER | CONVEYING
Port_2310504_1 | CABLECARRIER | CONVEYING
Port_2310815_0 | CABLECARRIER | CONVEYING
Port_2310856_2 | CABLECARRIER | CONVEYING
Port_2310815_1 | CABLECARRIER | CONVEYING
Port_2310827_2 | CABLECARRIER | CONVEYING
Port_2310821_0 | CABLECARRIER | CONVEYING
Port_2310827_1 | CABLECARRIER | CONVEYING
Port_2310821_1 | CABLECARRIER | CONVEYING
Port_2310868_0 | CABLECARRIER | CONVEYING
Port_2310898_2 | CABLECARRIER | CONVEYING
Port_2310868_1 | CABLECARRIER | CONVEYING
Port_2310878_2 | CABLECARRIER | CONVEYING
Port_2310874_0 | CABLECARRIER | CONVEYING
Port_2310878_1 | CABLECARRIER | CONVEYING
Port_2310874_1 | CABLECARRIER | CONVEYING
Port_2311383_0 | CABLECARRIER | CONVEYING
Port_2312286_2 | CABLECARRIER | CONVEYING
Port_2311383_1 | CABLECARRIER | CONVEYING
Port_2312284_3 | CABLECARRIER | CONVEYING
Port_2311429_1 | CABLECARRIER | CONVEYING
Port_2312258_1 | CABLECARRIER | CONVEYING
Port_2311674_0 | CABLECARRIER | CONVEYING
Port_2311987_1 | CABLECARRIER | CONVEYING
Port_2311674_1 | CABLECARRIER | CONVEYING
Port_2311813_3 | CABLECARRIER | CONVEYING
Port_2311675_1 | CABLECARRIER | CONVEYING
Port_2311814_0 | CABLECARRIER | CONVEYING
Port_2311813_1 | CABLECARRIER | CONVEYING
Port_2311814_1 | CABLECARRIER | CONVEYING
Port_2311987_2 | CABLECARRIER | CONVEYING
Port_2336143_0 | CABLECARRIER | CONVEYING
Port_2312257_2 | CABLECARRIER | CONVEYING
Port_2312285_0 | CABLECARRIER | CONVEYING
Port_2312284_2 | CABLECARRIER | CONVEYING
Port_2312285_1 | CABLECARRIER | CONVEYING
Port_2312515_1 | CABLECARRIER | CONVEYING
Port_2312516_1 | CABLECARRIER | CONVEYING
Port_2324686_2 | CABLECARRIER | CONVEYING
Port_2338470_0 | CABLECARRIER | CONVEYING
Port_2325132_0 | CABLECARRIER | CONVEYING
Port_2325354_2 | CABLECARRIER | CONVEYING
Port_2325132_1 | CABLECARRIER | CONVEYING
Port_2325357_2 | CABLECARRIER | CONVEYING
Port_2325191_1 | CABLECARRIER | CONVEYING
Port_2325357_1 | CABLECARRIER | CONVEYING
Port_2325349_0 | CABLECARRIER | CONVEYING
Port_2325352_1 | CABLECARRIER | CONVEYING
Port_2325349_1 | CABLECARRIER | CONVEYING
Port_2325354_1 | CABLECARRIER | CONVEYING
Port_2326121_0 | CABLECARRIER | CONVEYING
Port_2326337_2 | CABLECARRIER | CONVEYING
Port_2326121_1 | CABLECARRIER | CONVEYING
Port_2326340_2 | CABLECARRIER | CONVEYING
Port_2326207_0 | CABLECARRIER | CONVEYING
Port_2326208_1 | CABLECARRIER | CONVEYING
Port_2326207_1 | CABLECARRIER | CONVEYING
Port_2326337_1 | CABLECARRIER | CONVEYING
Port_2327158_0 | CABLECARRIER | CONVEYING
Port_2327786_2 | CABLECARRIER | CONVEYING
Port_2327589_0 | CABLECARRIER | CONVEYING
Port_2329642_1 | CABLECARRIER | CONVEYING
Port_2327589_1 | CABLECARRIER | CONVEYING
Port_2327786_1 | CABLECARRIER | CONVEYING
Port_2328513_0 | CABLECARRIER | CONVEYING
Port_2329910_2 | CABLECARRIER | CONVEYING
Port_2328513_1 | CABLECARRIER | CONVEYING
Port_2329913_2 | CABLECARRIER | CONVEYING
Port_2328534_0 | CABLECARRIER | CONVEYING
Port_2328618_1 | CABLECARRIER | CONVEYING
Port_2328534_1 | CABLECARRIER | CONVEYING
Port_2329811_1 | CABLECARRIER | CONVEYING
Port_2329783_0 | CABLECARRIER | CONVEYING
Port_2329811_2 | CABLECARRIER | CONVEYING
Port_2329783_1 | CABLECARRIER | CONVEYING
Port_2329910_1 | CABLECARRIER | CONVEYING
Port_2329857_0 | CABLECARRIER | CONVEYING
Port_2329882_2 | CABLECARRIER | CONVEYING
Port_2329857_1 | CABLECARRIER | CONVEYING
Port_2329913_1 | CABLECARRIER | CONVEYING
Port_2329977_0 | CABLECARRIER | CONVEYING
Port_2331507_2 | CABLECARRIER | CONVEYING
Port_2329977_1 | CABLECARRIER | CONVEYING
Port_2331510_2 | CABLECARRIER | CONVEYING
Port_2331246_1 | CABLECARRIER | CONVEYING
Port_2331507_1 | CABLECARRIER | CONVEYING
Port_2331668_1 | CABLECARRIER | CONVEYING
Port_2331675_2 | CABLECARRIER | CONVEYING
Port_2332227_0 | CABLECARRIER | CONVEYING
Port_2332278_2 | CABLECARRIER | CONVEYING
Port_2332227_1 | CABLECARRIER | CONVEYING
Port_2332280_2 | CABLECARRIER | CONVEYING
Port_2332250_0 | CABLECARRIER | CONVEYING
Port_2332251_1 | CABLECARRIER | CONVEYING
Port_2332250_1 | CABLECARRIER | CONVEYING
Port_2332278_1 | CABLECARRIER | CONVEYING
Port_2334370_0 | CABLECARRIER | CONVEYING
Port_2335331_2 | CABLECARRIER | CONVEYING
Port_2334370_1 | CABLECARRIER | CONVEYING
Port_2335332_2 | CABLECARRIER | CONVEYING
Port_2334402_0 | CABLECARRIER | CONVEYING
Port_2335315_1 | CABLECARRIER | CONVEYING
Port_2334402_1 | CABLECARRIER | CONVEYING
Port_2334974_1 | CABLECARRIER | CONVEYING
Port_2334794_0 | CABLECARRIER | CONVEYING
Port_2334974_2 | CABLECARRIER | CONVEYING
Port_2334794_1 | CABLECARRIER | CONVEYING
Port_2334976_2 | CABLECARRIER | CONVEYING
Port_2335025_0 | CABLECARRIER | CONVEYING
Port_2335315_2 | CABLECARRIER | CONVEYING
Port_2335025_1 | CABLECARRIER | CONVEYING
Port_2335332_1 | CABLECARRIER | CONVEYING
Port_2335380_0 | CABLECARRIER | CONVEYING
Port_2335956_1 | CABLECARRIER | CONVEYING
Port_2335380_1 | CABLECARRIER | CONVEYING
Port_2336005_1 | CABLECARRIER | CONVEYING
Port_2335381_0 | CABLECARRIER | CONVEYING
Port_2336005_2 | CABLECARRIER | CONVEYING
Port_2335381_1 | CABLECARRIER | CONVEYING
Port_2336008_2 | CABLECARRIER | CONVEYING
Port_2335384_0 | CABLECARRIER | CONVEYING
Port_2335956_2 | CABLECARRIER | CONVEYING
Port_2335384_1 | CABLECARRIER | CONVEYING
Port_2335959_2 | CABLECARRIER | CONVEYING
Port_2335412_0 | CABLECARRIER | CONVEYING
Port_2336365_1 | CABLECARRIER | CONVEYING
Port_2335412_1 | CABLECARRIER | CONVEYING
Port_2336328_1 | CABLECARRIER | CONVEYING
Port_2335413_0 | CABLECARRIER | CONVEYING
Port_2336328_2 | CABLECARRIER | CONVEYING
Port_2335413_1 | CABLECARRIER | CONVEYING
Port_2336331_2 | CABLECARRIER | CONVEYING
Port_2335416_0 | CABLECARRIER | CONVEYING
Port_2336365_2 | CABLECARRIER | CONVEYING
Port_2335416_1 | CABLECARRIER | CONVEYING
Port_2336368_2 | CABLECARRIER | CONVEYING
Port_2335471_0 | CABLECARRIER | CONVEYING
Port_2335476_1 | CABLECARRIER | CONVEYING
Port_2335471_1 | CABLECARRIER | CONVEYING
Port_2335473_1 | CABLECARRIER | CONVEYING
Port_2335472_0 | CABLECARRIER | CONVEYING
Port_2335473_2 | CABLECARRIER | CONVEYING
Port_2335472_1 | CABLECARRIER | CONVEYING
Port_2424704_1 | CABLECARRIER | CONVEYING
Port_2335475_0 | CABLECARRIER | CONVEYING
Port_2335476_2 | CABLECARRIER | CONVEYING
Port_2335475_1 | CABLECARRIER | CONVEYING
Port_2424736_1 | CABLECARRIER | CONVEYING
Port_2335701_1 | CABLECARRIER | CONVEYING
Port_2335959_1 | CABLECARRIER | CONVEYING
Port_2336143_1 | CABLECARRIER | CONVEYING
Port_2336368_1 | CABLECARRIER | CONVEYING
Port_2337095_0 | CABLECARRIER | CONVEYING
Port_2337105_2 | CABLECARRIER | CONVEYING
Port_2337095_1 | CABLECARRIER | CONVEYING
Port_2337113_1 | CABLECARRIER | CONVEYING
Port_2337107_0 | CABLECARRIER | CONVEYING
Port_2337113_2 | CABLECARRIER | CONVEYING
Port_2337107_1 | CABLECARRIER | CONVEYING
Port_2337964_1 | CABLECARRIER | CONVEYING
Port_2337969_2 | CABLECARRIER | CONVEYING
Port_2337967_1 | CABLECARRIER | CONVEYING
Port_2338791_0 | CABLECARRIER | CONVEYING
Port_2339934_2 | CABLECARRIER | CONVEYING
Port_2338791_1 | CABLECARRIER | CONVEYING
Port_2339778_1 | CABLECARRIER | CONVEYING
Port_2339777_1 | CABLECARRIER | CONVEYING
Port_2339935_0 | CABLECARRIER | CONVEYING
Port_2339934_1 | CABLECARRIER | CONVEYING
Port_2339935_1 | CABLECARRIER | CONVEYING
Port_2340113_1 | CABLECARRIER | CONVEYING
Port_2352250_1 | CABLE | ELECTRICAL
Port_2363237_1 | CABLE | ELECTRICAL
Port_2363266_1 | CABLE | ELECTRICAL
Port_2363934_1 | CABLE | ELECTRICAL
Port_2364550_1 | CABLE | ELECTRICAL
Port_2364594_1 | CABLE | ELECTRICAL
Port_2364630_1 | CABLE | ELECTRICAL
Port_2365665_1 | CABLE | ELECTRICAL
Port_2367435_1 | CABLE | ELECTRICAL
Port_2367606_1 | CABLE | ELECTRICAL
Port_2374514_1 | CABLE | ELECTRICAL
Port_2387059_1 | CABLE | ELECTRICAL
Port_2392435_1 | CABLE | ELECTRICAL
Port_2395991_1 | CABLE | ELECTRICAL
Port_2400026_1 | CABLE | ELECTRICAL
Port_2405598_1 | CABLE | ELECTRICAL
Port_2408090_1 | CABLE | ELECTRICAL
Port_2408096_1 | CABLE | ELECTRICAL
Port_2408111_1 | CABLE | ELECTRICAL
Port_2410632_1 | CABLE | ELECTRICAL
Port_2413524_1 | CABLE | ELECTRICAL
Port_2413603_1 | CABLE | ELECTRICAL
Port_2413690_1 | CABLE | ELECTRICAL
Port_2414716_1 | CABLE | ELECTRICAL
Port_2415081_1 | CABLE | ELECTRICAL
Port_2415179_1 | CABLE | ELECTRICAL
Port_2415234_1 | CABLE | ELECTRICAL
Port_2415254_1 | CABLE | ELECTRICAL
Port_2415471_1 | CABLE | ELECTRICAL
Port_2415766_1 | CABLE | ELECTRICAL
Port_2415800_1 | CABLE | ELECTRICAL
Port_2415846_1 | CABLE | ELECTRICAL
Port_2415856_1 | CABLE | ELECTRICAL
Port_2416209_1 | CABLE | ELECTRICAL
Port_2416704_1 | CABLE | ELECTRICAL
Port_2416875_1 | CABLE | ELECTRICAL
Port_2419691_1 | CABLE | ELECTRICAL
Port_2420754_1 | CABLE | ELECTRICAL
Port_2420812_1 | CABLE | ELECTRICAL
Port_2420884_1 | CABLE | ELECTRICAL
Port_2422005_1 | CABLE | ELECTRICAL
Port_2422221_1 | CABLE | ELECTRICAL
Port_2422924_1 | CABLE | ELECTRICAL
Port_2422938_1 | CABLE | ELECTRICAL
Port_2424037_2 | CABLECARRIER | CONVEYING
Port_2424038_1 | CABLECARRIER | CONVEYING
Port_2424511_0 | CABLECARRIER | CONVEYING
Port_2424703_1 | CABLECARRIER | CONVEYING
Port_2424511_1 | CABLECARRIER | CONVEYING
Port_2424704_2 | CABLECARRIER | CONVEYING
Port_2444417_0 | CABLECARRIER | CONVEYING
Port_2444429_1 | CABLECARRIER | CONVEYING
Port_2444417_1 | CABLECARRIER | CONVEYING
Port_2444486_1 | CABLECARRIER | CONVEYING
Port_2444453_0 | CABLECARRIER | CONVEYING
Port_2444486_2 | CABLECARRIER | CONVEYING
Port_2444453_1 | CABLECARRIER | CONVEYING
Port_2445509_1 | CABLECARRIER | CONVEYING
Port_2445215_0 | CABLECARRIER | CONVEYING
Port_2445506_2 | CABLECARRIER | CONVEYING
Port_2445215_1 | CABLECARRIER | CONVEYING
Port_2445509_2 | CABLECARRIER | CONVEYING
Port_2448309_1 | CABLE | ELECTRICAL
Port_2448857_1 | CABLE | ELECTRICAL
Port_2451360_1 | CABLE | ELECTRICAL
Port_2453719_1 | CABLE | ELECTRICAL
Port_2454933_1 | CABLE | ELECTRICAL
Port_2455920_1 | CABLE | ELECTRICAL
Port_2456058_0 | CABLECARRIER | CONVEYING
Port_2456058_1 | CABLECARRIER | CONVEYING

# IfcElectricDistributionBoard: #Nabíječka pro elektromobily:#Nabíječka pro elektromobily, #Nabíječka pro elektromobily:#Nabíječka pro elektromobily:1952595
In: 1.S
Type - PredefinedType: DISTRIBUTIONBOARD; Material: <Unnamed>, #Bílá
Type - CZ_ElementCommon - ElementProjectSpecificName: Nabíječka pro elektromobily; ElementProjectSpecificDescription: Dobíjecí stanice pro elektromobily; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: dobíjecí stanice
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: XDB
CZ_ElementCommon - Reference: EL01.1952595; ElementProjectSpecificIdentifier: NABÍJEČKA 4; StoreyProjectSpecificIdentifier: 1.S

# IfcLightFixture: #Světlo, kruhové:D300, přisazené (9)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: D300, přisazené; ElementProjectSpecificDescription: svítidlo kruhové přisazené LED 20W/4000K; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Světlo, kruhové:D300, přisazené:...) | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1240184 | B.1240184 | B | R-RS-LM0.07
1240203 | B.1240203 | B | R-RS-LM0.07
1240230 | B.1240230 | B | R-RS-LM0.07
1240240 | B.1240240 | B | R-RS-LM0.07
1251818 | B.1251818 | B | R-RS-LM0.08
1251826 | B.1251826 | B | R-RS-VZT.01
1945874 | B.1945874 | B | R-RS-LM0.09
2118024 | B.2118024 | YYYYYYYYYYYYYYY | R-RS-LM0.08
2118091 | B.2118091 | B | R-RS-LM0.08

# IfcLightFixture: #Světlo, obdélníkové:1237x95, přisazené C (14)
In: 5.NP
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1237x95, přisazené C; ElementProjectSpecificDescription: přisazené LED 76W/4000K; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 5.NP
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Světlo, obdélníkové:1237x95, přisazené C:...) | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1271709 | C.1271709 | 532 | R-RS-LM5.04
1271718 | C.1271718 | 533 | R-RS-LM5.04
1271728 | C.1271728 | 534 | R-RS-LM5.13
1271738 | C.1271738 | 535 | R-RS-LM5.13
1271744 | C.1271744 | 536 | R-RS-LM5.13
1271754 | C.1271754 | 537 | R-RS-LM5.13
1271762 | C.1271762 | 538 | R-RS-LM5.13
2287330 | C.2287330 | A21 | R-RS-LM5.15
2297964 | C.2297964 | A67 | R-RS-LM5.14
2297965 | C.2297965 | A86 | R-RS-LM5.14
2298298 | C.2298298 | A89 | R-RS-LM5.13
2298334 | C.2298334 | A95 | R-RS-LM5.13
2298506 | C.2298506 | A96 | R-RS-LM5.04
2298507 | C.2298507 | A97 | R-RS-LM5.04

# IfcLightFixture: #Světlo, obdélníkové:1270x95, přisazené (24)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1270x95, přisazené; ElementProjectSpecificDescription: Svítidlo přisazené LED 43W; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
CZ_ElementCommon - ElementProjectSpecificIdentifier: A2
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Světlo, obdélníkové:1270x95, přisazené:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1231466 | 5.NP | A2.1231466 | 5.NP | R-RS-LM1.01
1231523 | 5.NP | A2.1231523 | 5.NP | R-RS-LM1.01
1231954 | 1.NP | A2.1231954 | 1.NP | R-RS-LM1.02
1231955 | 1.NP | A2.1231955 | 1.NP | R-RS-LM1.02
1232193 | 1.NP mezipatro | A2.1232193 | 1.NP mezipatro | R-RS-LM1.02
1232194 | 1.NP mezipatro | A2.1232194 | 1.NP mezipatro | R-RS-LM1.02
1232510 | 2.NP mezipatro | A2.1232510 | 2.NP mezipatro | R-RS-LM1.02
1232512 | 3.NP | A2.1232512 | 3.NP | R-RS-LM1.02
1232513 | 2.NP mezipatro | A2.1232513 | 2.NP mezipatro | R-RS-LM1.02
1232514 | 2.NP | A2.1232514 | 2.NP | R-RS-LM1.02
1233032 | 3.NP mezipatro | A2.1233032 | 3.NP mezipatro | R-RS-LM1.02
1233035 | 3.NP mezipatro | A2.1233035 | 3.NP mezipatro | R-RS-LM1.02
1233036 | 3.NP | A2.1233036 | 3.NP | R-RS-LM1.02
1233243 | 4.NP mezipatro | A2.1233243 | 4.NP mezipatro | R-RS-LM1.02
1233245 | 4.NP | A2.1233245 | 4.NP | R-RS-LM1.02
1233246 | 4.NP mezipatro | A2.1233246 | 4.NP mezipatro | R-RS-LM1.02
1233247 | 4.NP | A2.1233247 | 4.NP | R-RS-LM1.02
1233335 | 5.NP | A2.1233335 | 5.NP | R-RS-LM1.01
1233337 | 5.NP | A2.1233337 | 5.NP | R-RS-LM1.01
1233461 | 5.NP | A2.1233461 | 5.NP | R-RS-LM1.02
1233463 | 5.NP | A2.1233463 | 5.NP | R-RS-LM1.02
1233464 | 5.NP | A2.1233464 | 5.NP | R-RS-LM1.02
1233465 | 2.NP | A2.1233465 | 2.NP | R-RS-LM1.02
1697931 | 5.NP | A2.1697931 | 5.NP | R-RS-LM1.02

# IfcLightFixture: Nouzové světlo N1_zed:NS_N1- (31)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificDescription: Nouzové světlo; ElementProjectSpecificName: NS_N1-; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: nouzové / únikové osvětlení
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
Pset_DistributionSystemCommon - Reference: RPO
Name (Nouzové světlo N1_zed:NS_N1-:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1595240 | 1.NP | N1.1595240 | 637 | 1.NP | RPO-N0.05
1595642 | 1.NP | N1.1595642 | N | 1.NP | RPO-N0.06
1595978 | 1.NP mezipatro | N1.1595978 | 640 | 1.NP mezipatro | RPO-N0.05
1596385 | 1.NP mezipatro | N1.1596385 | N | 1.NP mezipatro | RPO-N0.06
1608109 | 2.NP mezipatro | N1.1608109 | 670 | 2.NP mezipatro | RPO-N0.05
1608111 | 2.NP mezipatro | N1.1608111 | N | 2.NP mezipatro | RPO-N0.06
1608136 | 3.NP mezipatro | N1.1608136 | 672 | 3.NP mezipatro | RPO-N0.05
1608137 | 3.NP mezipatro | N1.1608137 | N | 3.NP mezipatro | RPO-N0.06
1608217 | 5.NP | N1.1608217 | 674 | 5.NP | RPO-N0.05
1608218 | 5.NP | N1.1608218 | N | 5.NP | RPO-N0.06
1608304 | 1.S | N1.1608304 | N | 1.S | RPO-N0.05
1608305 | 1.S | N1.1608305 | N | 1.S | RPO-N0.06
1608382 | 1.S | N1.1608382 | N | 1.S | RPO-N0.06
1608621 | 2.NP | N1.1608621 | 680 | 2.NP | RPO-N0.05
1608623 | 2.NP | N1.1608623 | N | 2.NP | RPO-N0.06
1608673 | 1.S | N1.1608673 | 682 | 1.S | RPO-N0.05
1608674 | 3.NP | N1.1608674 | N | 3.NP | RPO-N0.06
1608752 | 4.NP | N1.1608752 | 684 | 4.NP | RPO-N0.05
1608753 | 4.NP | N1.1608753 | N | 4.NP | RPO-N0.06
1608806 | 5.NP | N1.1608806 | 686 | 5.NP | RPO-N0.05
1608807 | 5.NP | N1.1608807 | N | 5.NP | RPO-N0.06
1608902 | 1.S | N1.1608902 | 688 | 1.S | RPO-N0.05
1608903 | 1.S | N1.1608903 | N | 1.S | RPO-N0.06
1612591 | 1.S | N1.1612591 | 727 | 1.S | RPO-N0.05
1903719 | 3.NP mezipatro | N1.1903719 | N5 | 3.NP mezipatro | RPO-N3.01
1947383 | 1.S | N1.1947383 | N24 | 1.S | RPO-N0.04
1947547 | 1.S | N1.1947547 | N25 | 1.S | RPO-N0.04
1956053 | 1.S mezipatro | N1.1956053 | N1 | 1.S mezipatro | RPO-N0.11
2291041 | 1.S | N1.2291041 | A26 | 1.S | RPO-N0.05
2352250 | 1.S | N1.2352250 | N1 | 1.S | RPO-N0.01
2451360 | 1.S | N1.2451360 | N6 | 1.S | RPO-N5.11

# IfcLightFixture: Nouzové světlo N5:NS_N5 (135)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificDescription: Nouzové světlo; ElementProjectSpecificName: NS_N5; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: nouzové / únikové osvětlení
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
Pset_DistributionSystemCommon - Reference: RPO
Name (Nouzové světlo N5:NS_N5:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1594028 | 1.NP mezipatro | N5.1594028 | N | 1.NP mezipatro | RPO-N1.01
1594316 | 2.NP | N5.1594316 | N | 2.NP | RPO-N2.11
1594341 | 1.NP mezipatro | N5.1594341 | N | 1.NP mezipatro | RPO-N1.01
1594358 | 1.NP mezipatro | N5.1594358 | N | 1.NP mezipatro | RPO-N1.01
1594372 | 1.NP mezipatro | N5.1594372 | N | 1.NP mezipatro | RPO-N1.01
1594382 | 1.NP mezipatro | N5.1594382 | N | 1.NP mezipatro | RPO-N1.01
1594394 | 1.NP mezipatro | N5.1594394 | N | 1.NP mezipatro | RPO-N1.01
1594406 | 1.NP mezipatro | N5.1594406 | N | 1.NP mezipatro | RPO-N1.01
1594418 | 1.NP mezipatro | N5.1594418 | N | 1.NP mezipatro | RPO-N1.01
1594771 | 1.NP mezipatro | N5.1594771 | N1 | 1.NP mezipatro | RPO-N0.01
1594866 | 1.NP mezipatro | N5.1594866 | N1 | 1.NP mezipatro | RPO-N0.02
1594905 | 2.NP | N5.1594905 | N1 | 2.NP | RPO-N0.01
1595022 | 2.NP | N5.1595022 | N1 | 2.NP | RPO-N0.02
1595067 | 2.NP | N5.1595067 | N1 | 2.NP | RPO-N2.11
1595088 | 2.NP | N5.1595088 | N | 2.NP | RPO-N2.11
1595098 | 2.NP | N5.1595098 | N | 2.NP | RPO-N2.11
1595108 | 2.NP | N5.1595108 | N | 2.NP | RPO-N2.11
1595120 | 2.NP | N5.1595120 | N | 2.NP | RPO-N2.11
1595132 | 2.NP | N5.1595132 | N | 2.NP | RPO-N2.11
1595146 | 2.NP | N5.1595146 | N1 | 2.NP | RPO-N2.11
1598872 | 3.NP | N5.1598872 | N | 3.NP | RPO-N3.11
1599027 | 3.NP | N5.1599027 | N | 3.NP | RPO-N3.11
1599061 | 3.NP | N5.1599061 | N | 3.NP | RPO-N3.11
1599075 | 3.NP | N5.1599075 | N | 3.NP | RPO-N3.11
1599089 | 3.NP | N5.1599089 | N | 3.NP | RPO-N3.11
1599099 | 3.NP | N5.1599099 | N | 3.NP | RPO-N3.11
1599107 | 3.NP | N5.1599107 | N | 3.NP | RPO-N3.11
1599119 | 3.NP | N5.1599119 | N | 3.NP | RPO-N3.11
1599197 | 2.NP mezipatro | N5.1599197 | N1 | 2.NP mezipatro | RPO-N2.01
1599273 | 2.NP mezipatro | N5.1599273 | N1 | 2.NP mezipatro | RPO-N2.01
1599308 | 2.NP mezipatro | N5.1599308 | N1 | 2.NP mezipatro | RPO-N2.01
1599320 | 2.NP mezipatro | N5.1599320 | N1 | 2.NP mezipatro | RPO-N2.01
1599334 | 2.NP mezipatro | N5.1599334 | N1 | 2.NP mezipatro | RPO-N2.01
1599366 | 2.NP mezipatro | N5.1599366 | N1 | 2.NP mezipatro | RPO-N2.01
1599378 | 2.NP mezipatro | N5.1599378 | N1 | 2.NP mezipatro | RPO-N2.01
1599392 | 2.NP mezipatro | N5.1599392 | N1 | 2.NP mezipatro | RPO-N2.01
1599750 | 3.NP | N5.1599750 | N1 | 3.NP | RPO-N0.01
1599751 | 2.NP mezipatro | N5.1599751 | N1 | 2.NP mezipatro | RPO-N0.01
1599764 | 3.NP | N5.1599764 | N1 | 3.NP | RPO-N0.02
1599777 | 2.NP mezipatro | N5.1599777 | N1 | 2.NP mezipatro | RPO-N0.02
1609587 | 1.S | N5.1609587 | N1 | 1.S | RPO-N0.03
1609803 | 1.S | N5.1609803 | N1 | 1.S | RPO-N0.03
1609853 | 1.S | N5.1609853 | N1 | 1.S | RPO-N0.04
1609869 | 1.S | N5.1609869 | N1 | 1.S | RPO-N0.03
1610437 | 1.S | N5.1610437 | N1 | 1.S | RPO-N0.04
1610548 | 1.S | N5.1610548 | N1 | 1.S | RPO-N0.04
1610942 | 1.S | N5.1610942 | N1 | 1.S | RPO-N0.03
1610951 | 1.S | N5.1610951 | N | 1.S | RPO-N0.03
1610963 | 1.S | N5.1610963 | N | 1.S | RPO-N0.03
1610975 | 1.S | N5.1610975 | N | 1.S | RPO-N0.03
1610987 | 1.S | N5.1610987 | N | 1.S | RPO-N0.03
1610995 | 1.S | N5.1610995 | N | 1.S | RPO-N0.03
1611007 | 1.S | N5.1611007 | N1 | 1.S | RPO-N0.03
1619393 | 5.NP | N5.1619393 | N1 | 5.NP | RPO-N5.11
1619801 | 5.NP | N5.1619801 | N1 | 5.NP | RPO-N0.01
1625320 | 5.NP | N5.1625320 | N1 | 5.NP | RPO-N5.11
1659258 | 1.S mezipatro | N5.1659258 | N1 | 1.S mezipatro | RPO-N0.11
1659332 | 1.S mezipatro | N5.1659332 | N1 | 1.S mezipatro | RPO-N0.11
1659353 | 1.S mezipatro | N5.1659353 | N1 | 1.S mezipatro | RPO-N0.11
1659365 | 1.S mezipatro | N5.1659365 | N1 | 1.S mezipatro | RPO-N0.11
1659377 | 1.S mezipatro | N5.1659377 | N1 | 1.S mezipatro | RPO-N0.11
1659393 | 1.S mezipatro | N5.1659393 | N1 | 1.S mezipatro | RPO-N0.11
1659401 | 1.S mezipatro | N5.1659401 | N1 | 1.S mezipatro | RPO-N0.11
1659503 | 1.S mezipatro | N5.1659503 | N1 | 1.S mezipatro | RPO-N0.01
1659517 | 1.S mezipatro | N5.1659517 | N1 | 1.S mezipatro | RPO-N0.02
1659659 | 1.NP | N5.1659659 | N | 1.NP | RPO-N1.11
1659904 | 1.NP | N5.1659904 | N | 1.NP | RPO-N1.11
1659915 | 1.NP | N5.1659915 | N | 1.NP | RPO-N1.11
1659927 | 1.NP | N5.1659927 | N | 1.NP | RPO-N1.11
1659941 | 1.NP | N5.1659941 | N | 1.NP | RPO-N1.11
1659955 | 1.NP | N5.1659955 | N | 1.NP | RPO-N1.11
1659971 | 1.NP | N5.1659971 | N | 1.NP | RPO-N1.11
1659989 | 1.NP | N5.1659989 | N | 1.NP | RPO-N1.11
1660080 | 1.NP | N5.1660080 | N1 | 1.NP | RPO-N0.01
1660099 | 1.NP | N5.1660099 | N1 | 1.NP | RPO-N0.02
1661919 | 1.S mezipatro | N5.1661919 | N | 1.S mezipatro | RPO-N0.11
1661948 | 1.S | N5.1661948 | N1 | 1.S | RPO-N0.03
1661956 | 1.S | N5.1661956 | N1 | 1.S | RPO-N0.03
1669580 | 1.NP mezipatro | N5.1669580 | N1 | 1.NP mezipatro | RPO-N1.01
1669961 | 1.NP | N5.1669961 | N | 1.NP | RPO-N1.11
1671023 | 2.NP | N5.1671023 | N1 | 2.NP | RPO-N2.11
1671269 | 2.NP mezipatro | N5.1671269 | N1 | 2.NP mezipatro | RPO-N2.01
1675168 | 3.NP mezipatro | N5.1675168 | N | 3.NP mezipatro | RPO-N3.01
1675368 | 4.NP mezipatro | N5.1675368 | N | 4.NP mezipatro | RPO-N4.01
1675629 | 4.NP | N5.1675629 | N | 4.NP | RPO-N4.11
1675851 | 3.NP mezipatro | N5.1675851 | N | 3.NP mezipatro | RPO-N3.01
1675864 | 3.NP mezipatro | N5.1675864 | N | 3.NP mezipatro | RPO-N3.01
1675876 | 3.NP mezipatro | N5.1675876 | N | 3.NP mezipatro | RPO-N3.01
1675892 | 3.NP mezipatro | N5.1675892 | N | 3.NP mezipatro | RPO-N3.01
1675904 | 3.NP mezipatro | N5.1675904 | N | 3.NP mezipatro | RPO-N3.01
1675916 | 3.NP mezipatro | N5.1675916 | N | 3.NP mezipatro | RPO-N3.01
1675928 | 3.NP mezipatro | N5.1675928 | N | 3.NP mezipatro | RPO-N3.01
1676006 | 3.NP mezipatro | N5.1676006 | N1 | 3.NP mezipatro | RPO-N0.01
1676018 | 3.NP mezipatro | N5.1676018 | N1 | 3.NP mezipatro | RPO-N0.02
1676123 | 4.NP | N5.1676123 | N | 4.NP | RPO-N4.11
1676134 | 4.NP | N5.1676134 | N | 4.NP | RPO-N4.11
1676144 | 4.NP | N5.1676144 | N | 4.NP | RPO-N4.11
1676154 | 4.NP | N5.1676154 | N | 4.NP | RPO-N4.11
1676168 | 4.NP | N5.1676168 | N | 4.NP | RPO-N4.11
1676184 | 4.NP | N5.1676184 | N | 4.NP | RPO-N4.11
1676194 | 4.NP | N5.1676194 | N | 4.NP | RPO-N4.11
1676293 | 4.NP | N5.1676293 | N1 | 4.NP | RPO-N0.01
1676313 | 4.NP | N5.1676313 | N1 | 4.NP | RPO-N0.02
1677512 | 4.NP mezipatro | N5.1677512 | N | 4.NP mezipatro | RPO-N4.01
1677545 | 4.NP mezipatro | N5.1677545 | N | 4.NP mezipatro | RPO-N4.01
1677559 | 4.NP mezipatro | N5.1677559 | N | 4.NP mezipatro | RPO-N4.01
1677567 | 4.NP mezipatro | N5.1677567 | N | 4.NP mezipatro | RPO-N4.01
