Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: b05c87af-9680-47f1-96fe-01b4f185d445, NumberOfSaves: 117]
File name: C:\Users\Petr.Kadera\Downloads\SO01-ELE.ifc
Time: 2025-04-22T13:44:50+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (CSY) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:#Hlavní (13)
Name | LongName | Elevation (mm)
1.S | 1.S | 0
1.S mezipatro | 1.S mezipatro | 1500
1.NP | 1.NP | 3000
1.NP mezipatro | 1.NP mezipatro | 4500
2.NP | 2.NP | 6000
2.NP mezipatro | 2.NP mezipatro | 7500
3.NP | 3.NP | 9000
3.NP mezipatro | 3.NP mezipatro | 10500
4.NP | 4.NP | 12000
4.NP mezipatro | 4.NP mezipatro | 13500
5.NP | 5.NP | 15000
5.NP mezipatro | 5.NP mezipatro | 16500
Sřecha | Sřecha | 20200

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:1200x600x250, Rozvadeč SIL_DIS:RPO:1743778
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1200x600x250; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: ROZ.1743778; ElementProjectSpecificIdentifier: RPO; StoreyProjectSpecificIdentifier: 1.S

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:1800x600x400 (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1800x600x400; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (Rozvadeč SIL_DIS:...) | Reference | ElementProjectSpecificIdentifier
CBS:1745404 | ROZ.1745404 | CBS
UPFD:1745599 | ROZ.1745599 | UPFD

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:2100x1000x250, Rozvadeč SIL_DIS:R-RS:1745652
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 2100x1000x250; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: ROZ.1745652; ElementProjectSpecificIdentifier: R-RS; StoreyProjectSpecificIdentifier: 1.S

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:2100x1200x400, Rozvadeč SIL_DIS:R-RH:2242380
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 2100x1200x400; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: ROZ.2242380; ElementProjectSpecificIdentifier: R-RH; StoreyProjectSpecificIdentifier: 1.S

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:2100x800x400 (3)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 2100x800x400; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (Rozvadeč SIL_DIS:...) | Reference | ElementProjectSpecificIdentifier
R-RH:1743337 | ROZ.1743337 | R-RH
RE-G:2242900 | ROZ.2242900 | RE-G
RE-G:2243047 | ROZ.2243047 | RE-G

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:327x362x95, Rozvadeč SIL_DIS:HZB:1754914
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 327x362x95; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: ROZ.1754914; ElementProjectSpecificIdentifier: HZB; StoreyProjectSpecificIdentifier: 1.S

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:600x400x250 (5)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 600x400x250; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
Name (Rozvadeč SIL_DIS:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
R-METEO:1723489 | 5.NP mezipatro | ROZ.1723489 | 7 | 5.NP mezipatro
R-MĚNIČ:1723914 | 5.NP mezipatro | ROZ.1723914 | 8 | 5.NP mezipatro
ROZVÁDĚČ RDC:1723920 | 5.NP mezipatro | ROZ.1723920 | 9 | 5.NP mezipatro
RJSV:1745843 | 1.S | ROZ.1745843 | RJSV | 1.S
RJSV:1745849 | 1.S | ROZ.1745849 | RJSV | 1.S

# IfcBuildingElementProxy: Rozvadeč SIL_DIS:750x550x290, Rozvadeč SIL_DIS:R-USM:1757122
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 750x550x290; ElementProjectSpecificDescription: Rozvaděč pro napojení v síti TN-C-S 400V/ 50Hz/ 3 NPE/ 400A; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: ROZ.1757122; ElementProjectSpecificIdentifier: R-USM; StoreyProjectSpecificIdentifier: 1.S

# IfcBuildingElementProxy: SIL- Rozvadeč SIL_upravitelný:482x472x592, SIL- Rozvadeč SIL_upravitelný:BATERIE FVE:2453719
In: 5.NP
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 482x472x592; ElementProjectSpecificDescription: Baterie FVE; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: rozvaděče ESL
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: JK; CCI_ComponentsCode: WDA
CZ_ElementCommon - Reference: ROZ.2453719; ElementProjectSpecificIdentifier: BATERIE FVE; StoreyProjectSpecificIdentifier: 5.NP

# IfcBuildingElementProxy: SIL-Central stop_CS:SIL-Central stop_CS, SIL-Central stop_CS:SIL-Central stop_CS:1859834
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Central stop_CS; ElementProjectSpecificDescription: Tlačítko central stop; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: vypínač, spínač, čidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: QAB
CZ_ElementCommon - Reference: CS.1859834; ElementProjectSpecificIdentifier: CS; StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: RPO
Pset_JunctionBoxTypeCommon - Reference: RPO-CS

# IfcBuildingElementProxy: SIL-FVE panel:SIL-FVE panel (60)
In: Sřecha
Type - Material: <Unnamed>, #FV panel
Type - CZ_DTcommon - DT_name: fotovoltaické / solární panely
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-FVE panel; ElementProjectSpecificDescription: Fotovoltarický panel; ElementProjectObjectIdentifier: SO01
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: GCA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: Sřecha
Qto_SlabBaseQuantities - NetArea: 3.47
Name (SIL-FVE panel:R:...) | Reference | ElementProjectSpecificIdentifier
1763709 | FVE.1763709 | R-RE-J
1765966 | FVE.1765966 | R-RE-K
1765977 | FVE.1765977 | R-RE-L
1765985 | FVE.1765985 | R-RE-M
1765995 | FVE.1765995 | R-RE-N
1766009 | FVE.1766009 | R-RE-O
1766057 | FVE.1766057 | R-RE-P
1766143 | FVE.1766143 | R-RE-Q
1766155 | FVE.1766155 | R-RE-R
1766163 | FVE.1766163 | R-RE-S
1766175 | FVE.1766175 | R-RE-T
1766187 | FVE.1766187 | R-RE-U
1766224 | FVE.1766224 | R-RE-V
1766226 | FVE.1766226 | R-RE-W
1766227 | FVE.1766227 | R-RE-X
1766228 | FVE.1766228 | R-RE-Y
1766229 | FVE.1766229 | R-RE-Z
1766230 | FVE.1766230 | R-RE-AA
1766231 | FVE.1766231 | R-RE-BB
1766232 | FVE.1766232 | R-RE-CC
1766233 | FVE.1766233 | R-RE-DD
1766234 | FVE.1766234 | R-RE-EE
1766235 | FVE.1766235 | R-RE-FF
1766236 | FVE.1766236 | R-RE-GG
1766296 | FVE.1766296 | R-RE-HH
1766297 | FVE.1766297 | R-RE-II
1766298 | FVE.1766298 | R-RE-JJ
1766299 | FVE.1766299 | R-RE-KK
1766300 | FVE.1766300 | R-RE-LL
1766301 | FVE.1766301 | R-RE-MM
1766302 | FVE.1766302 | R-RE-NN
1766303 | FVE.1766303 | R-RE-OO
1766304 | FVE.1766304 | R-RE-PP
1766305 | FVE.1766305 | R-RE-QQ
1766306 | FVE.1766306 | R-RE-RR
1766307 | FVE.1766307 | R-RE-SS
1766325 | FVE.1766325 | R-RE-TT
1766326 | FVE.1766326 | R-RE-UU
1766327 | FVE.1766327 | R-RE-VV
1766328 | FVE.1766328 | R-RE-WW
1766329 | FVE.1766329 | R-RE-XX
1766330 | FVE.1766330 | R-RE-YY
1766331 | FVE.1766331 | R-RE-ZZ
1766332 | FVE.1766332 | R-RE-AAA
1766333 | FVE.1766333 | R-RE-BBB
1766334 | FVE.1766334 | R-RE-CCC
1766335 | FVE.1766335 | R-RE-DDD
1766336 | FVE.1766336 | R-RE-EEE
1766344 | FVE.1766344 | R-RE-FFF
1766345 | FVE.1766345 | R-RE-GGG
1766346 | FVE.1766346 | R-RE-HHH
1766347 | FVE.1766347 | R-RE-III
1766348 | FVE.1766348 | R-RE-JJJ
1766349 | FVE.1766349 | R-RE-KKK
1766350 | FVE.1766350 | R-RE-LLL
1766351 | FVE.1766351 | R-RE-MMM
1766352 | FVE.1766352 | R-RE-NNN
1766353 | FVE.1766353 | R-RE-OOO
1766354 | FVE.1766354 | R-RE-PPP
1766355 | FVE.1766355 | R-RE-QQQ

# IfcBuildingElementProxy: SIL-Jednofázový vývod:SIL-Jednofázový vývod (34)
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Jednofázový vývod; ElementProjectSpecificDescription: Kabelový vývod
Name (SIL-Jednofázový vývod:SIL-Jednofázový vývod:...) | In | ElementProjectSpecificIdentifier
1930778 | 1.S | Vývod pro ventilátor 2
1931652 | 1.S | Vývod pro ventilátor 1
2192156 | 5.NP | VÝTAH
2193436 | 5.NP | Výtah
2193713 | 5.NP | STŘEŠNÍ VPUST
2193938 | 5.NP | STŘEŠNÍ VPUST
2194223 | 5.NP | STŘEŠNÍ VPUST
2194429 | 5.NP | STŘEŠNÍ VPUST
2194532 | 5.NP | STŘEŠNÍ VPUST
2194596 | 5.NP | STŘEŠNÍ VPUST
2194670 | 5.NP | STŘEŠNÍ VPUST
2195088 | 5.NP | RPO-SF 1.1.01
2395991 | 5.NP | Napojení topný kabel ZTI - žlab
2400026 | 4.NP mezipatro | Napojení topný kabel ZTI - žlab
2405598 | 1.S mezipatro | NAP. VENT. VZT (EF 01.1.01)
2408090 | 3.NP mezipatro | NAP. VENT. VZT (EF 3.1.01)
2408096 | 2.NP mezipatro | NAP. VENT. VZT (EF 2.1.01)
2408111 | 1.NP mezipatro | NAP. VENT. VZT (EF 1.1.01)
2414716 | 1.S | Vývod VZT
2415179 | 1.S | Vývod VZT
2415234 | 1.S | Vývod VZT
2415254 | 1.S | Vývod VZT
2415471 | 1.S | Vývod VZT CHLAZENÍ
2415766 | 1.S | Vývod VZT CHLAZENÎ
2415800 | 1.S | Vývod VZT CHLAZENÏ
2415846 | 1.S | Vývod VZT CHLAZENÐ
2415856 | 1.S | Vývod VZT CHLAZENÑ
2416209 | 1.S | NAP. POŽÁRNÍ KLAPKY
2419691 | 1.S | Vývod-venkovní osvětlení LOGO
2420884 | 1.S | Vývod 230W
2422005 | 1.S | Vývod 230Y
2422221 | 1.S | Vývod 230Z
2454933 | 1.S | RS-VZT-ACC-05.1.01 | CZ_ElementCommon - ElementProjectSpecificDescription: Vývod 230V
2455920 | 1.S | RS-VZT-ACC-05.1.02 | CZ_ElementCommon - ElementProjectSpecificDescription: Vývod 230V

# IfcBuildingElementProxy: SIL-Tlačítko stop FVE:SIL-Tlačítko stop FVE, SIL-Tlačítko stop FVE:SIL-Tlačítko stop FVE:1862867
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Tlačítko stop FVE; ElementProjectSpecificDescription: Tlačítko FVE; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: vypínač, spínač, čidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: QAB
CZ_ElementCommon - Reference: TL.1862867; ElementProjectSpecificIdentifier: Stop FVE; StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: RPO
Pset_JunctionBoxTypeCommon - Reference: RPO-Stop FVE

# IfcBuildingElementProxy: SIL-Tlačítko stop NAB:SIL-Tlačítko stop NAB, SIL-Tlačítko stop NAB:SIL-Tlačítko stop NAB:1864737
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Tlačítko stop NAB; ElementProjectSpecificDescription: Tlačítko NAB; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: vypínač, spínač, čidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: QAB
CZ_ElementCommon - Reference: TL.1864737; ElementProjectSpecificIdentifier: Stop NAB; StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: RPO
Pset_JunctionBoxTypeCommon - Reference: RPO-Stop NAB

# IfcBuildingElementProxy: SIL-Tlačítko_větrání CHUC:SIL-Tlačítko_větrání CHUC (24)
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Tlačítko_větrání CHUC; ElementProjectSpecificDescription: Tlačítko CHUC
CZ_ElementCommon - ElementProjectSpecificIdentifier: Větrání CHUC
Name (SIL-Tlačítko_větrání CHUC:SIL-Tlačítko_větrání CHUC:...) | In
1627385 | 5.NP
1627600 | 5.NP
1628134 | 4.NP
1628135 | 4.NP
1628161 | 3.NP
1628162 | 3.NP
1628188 | 2.NP
1628213 | 1.NP
1628214 | 1.NP
1628233 | 1.S
1628234 | 1.S
1705825 | 2.NP
1706206 | 2.NP mezipatro
1708840 | 5.NP mezipatro
1708852 | 4.NP mezipatro
1708863 | 3.NP mezipatro
1708874 | 1.NP mezipatro
1708885 | 1.S mezipatro
1709746 | 2.NP mezipatro
1709748 | 5.NP mezipatro
1709749 | 4.NP mezipatro
1709750 | 3.NP mezipatro
1709751 | 1.NP mezipatro
1709752 | 1.S mezipatro

# IfcBuildingElementProxy: SIL-Total stop_TS:SIL-Total stop_TS, SIL-Total stop_TS:SIL-Total stop_TS:1861242
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Total stop_TS; ElementProjectSpecificDescription: Tlačítko totall stop; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: vypínač, spínač, čidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: XDD
CZ_ElementCommon - Reference: TS.1861242; ElementProjectSpecificIdentifier: TS; StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: RPO
Pset_JunctionBoxTypeCommon - Reference: RPO-TS

# IfcBuildingElementProxy: SIL-termostat:SIL-termostat, SIL-termostat:SIL-termostat, 0 V, Jeden Fáze, 2 Vodiče:2410632
In: 5.NP
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-termostat; ElementProjectSpecificDescription: -
CZ_ElementCommon - ElementProjectSpecificIdentifier: TERMOSTAT

# IfcBuildingElementProxy: Střídavý přepínač.0001:Střídavý přepínač.0001 (9)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Střídavý přepínač.0001; ElementProjectSpecificDescription: Přepínač; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificIdentifier: PREPINAC
Type - CZ_DTcommon - DT_name: vypínač, spínač, čidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: QAB
Pset_DistributionSystemCommon - Reference: R-RS
Name (Střídavý přepínač.0001:Střídavý přepínač.0001:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1263481 | 1.S | PREPINAC.1263481 | 6 | 1.S | R-RS-LM0.01
1264438 | 1.S | PREPINAC.1264438 | 13 | 1.S | R-RS-LM0.02
1264485 | 1.S | PREPINAC.1264485 | 14 | 1.S | R-RS-LM0.03
1264708 | 1.S | PREPINAC.1264708 | 15 | 1.S | R-RS-LM0.04
1264834 | 1.S | PREPINAC.1264834 | 16 | 1.S | R-RS-LM0.08
1267365 | 1.S | PREPINAC.1267365 | 29 | 1.S | R-RS-LM0.06
1267414 | 1.S | PREPINAC.1267414 | 30 | 1.S | R-RS-LM0.05
1943059 | 1.S | PREPINAC.1943059 | Vývod pro ventilátor 9 | 1.S | R-RS-LM0.09
2448857 | 5.NP | PREPINAC.2448857 |  | 5.NP | R-RS-LM5.04

# IfcBuildingElementProxy: Transformer:Trafo, Transformer:Trafo:1740019
In: 1.S
Type - Material: ClearanceZone, CastResin-Red-Matte, Plastic-Black-Matte, Metal-Steel-Powdercoated-Black, Metal-Aluminium-Satin, Metal-Steel-Satin
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Trafo; ElementProjectSpecificDescription: Trafo
CZ_ElementCommon - ElementProjectSpecificIdentifier: 10

# IfcBuildingElementProxy: Zásuvka 230V_1f_16A:Zásuvka 230V_1f_16A (25)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Zásuvka 230V_1f_16A; ElementProjectSpecificDescription: Zásuvka 230V; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificIdentifier: 230/16A/1F
Type - CZ_DTcommon - DT_name: zásuvka (a podlahový box) ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: XDB
Pset_DistributionSystemCommon - Reference: R-RS
Name (Zásuvka 230V_1f_16A:Zásuvka 230V_1f_16A:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1268014 | 1.S | 230/16A/1F.1268014 | Zásuvka 230V | 1.S | R-RS-Z0.04
1712655 | 1.S | 230/16A/1F.1712655 | Zásuvka 230V | 1.S | R-RS-Z0.03
1712662 | 1.S | 230/16A/1F.1712662 | Zásuvka 230V | 1.S | R-RS-Z0.02
1712680 | 1.S | 230/16A/1F.1712680 | Zásuvka 230V | 1.S | R-RS-Z0.06
1712686 | 1.S | 230/16A/1F.1712686 | Zásuvka 230V | 1.S | R-RS-Z0.05
1714691 | 1.S | 230/16A/1F.1714691 | Zásuvka 230V | 1.S | R-RS-Z0.02
1942785 | 1.S | 230/16A/1F.1942785 | Zásuvka 230V | 1.S | R-RS-Z0.12
1943294 | 1.S | 230/16A/1F.1943294 | Zásuvka 230V | 1.S | R-RS-Z0.08
1943727 | 1.S | 230/16A/1F.1943727 | Zásuvka 230V | 1.S | R-RS-Z0.24
1943778 | 1.S | 230/16A/1F.1943778 | Zásuvka 230V POKLADNY 1 | 1.S | R-RS-Z0.02
1950758 | 1.S | 230/16A/1F.1950758 | Zásuvka 230V | 1.S | R-RS-Z0.10
2178382 | 1.S | 230/16A/1F.2178382 | Zásuvka 230V | 1.S | R-RS-Z0.09
2179103 | 1.S | 230/16A/1F.2179103 | Zásuvka 230V | 1.S | R-RS-Z0.07
2180056 | 1.S | 230/16A/1F.2180056 | Zásuvka 230V | 1.S | R-RS-Z0.11
2363237 | 1.S | 230/16A/1F.2363237 | Zásuvka 230V | 1.S | R-RS-Z0.04
2363266 | 1.S | 230/16A/1F.2363266 | Zásuvka 230V POKLADNY 5 | 1.S | R-RS-Z0.03
2363934 | 1.S | 230/16A/1F.2363934 | Zásuvka | 1.S | R-RS-Z0.23
2364550 | 1.S | 230/16A/1F.2364550 | Zásuvka 230V | 1.S | R-RS-Z0.20
2364594 | 1.S | 230/16A/1F.2364594 | Zásuvka 230V | 1.S | R-RS-Z0.21
2364630 | 1.S | 230/16A/1F.2364630 | Zásuvka 230V | 1.S | R-RS-Z0.21
2365665 | 1.S | 230/16A/1F.2365665 | Zásuvka 230V | 1.S | R-RS-Z0.25
2392435 | 1.S | 230/16A/1F.2392435 | Zásuvka 230V | 1.S | R-RS-Z0.07
2420754 | 1.S | 230/16A/1F.2420754 | Zásuvka 230V | 1.S | R-RS-Z0-RACK
2420812 | 1.S | 230/16A/1F.2420812 | Zásuvka 230V | 1.S | R-RS-Z0-CCTV
2448309 | 5.NP | 230/16A/1F.2448309 |  | 5.NP | R-RS-Z5.01

# IfcCableCarrierFitting: M_Horizontální ohyb kanálu:Standardní (86)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Ohyb; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
Name (M_Horizontální ohyb kanálu:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier
1637089 | 2.NP | xxx.1637089 | 2.NP
1638125 | 2.NP mezipatro | xxx.1638125 | 2.NP mezipatro
1638187 | 2.NP mezipatro | xxx.1638187 | 2.NP mezipatro
1638192 | 2.NP mezipatro | xxx.1638192 | 2.NP mezipatro
1638704 | 2.NP mezipatro | xxx.1638704 | 2.NP mezipatro
1646149 | 1.S | xxx.1646149 | 1.S
1647881 | 1.S | xxx.1647881 | 1.S
1792725 | 5.NP | xxx.1792725 | 5.NP
2047137 | 3.NP | xxx.2047137 | 3.NP
2047152 | 3.NP | xxx.2047152 | 3.NP
2047178 | 3.NP mezipatro | xxx.2047178 | 3.NP mezipatro
2047488 | 4.NP mezipatro | xxx.2047488 | 4.NP mezipatro
2047511 | 4.NP mezipatro | xxx.2047511 | 4.NP mezipatro
2052964 | 1.NP | xxx.2052964 | 1.NP
2052986 | 1.NP mezipatro | xxx.2052986 | 1.NP mezipatro
2053004 | 1.NP mezipatro | xxx.2053004 | 1.NP mezipatro
2053009 | 1.NP mezipatro | xxx.2053009 | 1.NP mezipatro
2233165 | 1.S mezipatro | xxx.2233165 | 1.S mezipatro
2233183 | 1.S mezipatro | xxx.2233183 | 1.S mezipatro
2233271 | 1.S mezipatro | xxx.2233271 | 1.S mezipatro
2233273 | 1.S mezipatro | xxx.2233273 | 1.S mezipatro
2287777 | 4.NP | xxx.2287777 | 4.NP
2288890 | 4.NP | xxx.2288890 | 4.NP
2289001 | 4.NP | xxx.2289001 | 4.NP
2290475 | 1.S | xxx.2290475 | 1.S
2290503 | 1.S | xxx.2290503 | 1.S
2290767 | 4.NP mezipatro | xxx.2290767 | 4.NP mezipatro
2290809 | 4.NP mezipatro | xxx.2290809 | 4.NP mezipatro
2294347 | 1.S mezipatro | xxx.2294347 | 1.S mezipatro
2294505 | 1.S mezipatro | xxx.2294505 | 1.S mezipatro
2301215 | 5.NP | xxx.2301215 | 5.NP
2302967 | 4.NP mezipatro | xxx.2302967 | 4.NP mezipatro
2304012 | 4.NP mezipatro | xxx.2304012 | 4.NP mezipatro
2304453 | 3.NP | xxx.2304453 | 3.NP
2304476 | 3.NP | xxx.2304476 | 3.NP
2305362 | 4.NP | xxx.2305362 | 4.NP
2305781 | 2.NP | xxx.2305781 | 2.NP
2305995 | 2.NP | xxx.2305995 | 2.NP
2305996 | 2.NP | xxx.2305996 | 2.NP
2306141 | 2.NP | xxx.2306141 | 2.NP
2306344 | 2.NP | xxx.2306344 | 2.NP
2306637 | 2.NP | xxx.2306637 | 2.NP
2306980 | 2.NP mezipatro | xxx.2306980 | 2.NP mezipatro
2308139 | 2.NP mezipatro | xxx.2308139 | 2.NP mezipatro
2308140 | 2.NP mezipatro | xxx.2308140 | 2.NP mezipatro
2308194 | 2.NP mezipatro | xxx.2308194 | 2.NP mezipatro
2308195 | 2.NP mezipatro | xxx.2308195 | 2.NP mezipatro
2309562 | 3.NP | xxx.2309562 | 3.NP
2309563 | 3.NP | xxx.2309563 | 3.NP
2309591 | 3.NP | xxx.2309591 | 3.NP
2309781 | 3.NP mezipatro | xxx.2309781 | 3.NP mezipatro
2310019 | 3.NP mezipatro | xxx.2310019 | 3.NP mezipatro
2310827 | 3.NP mezipatro | xxx.2310827 | 3.NP mezipatro
2310856 | 3.NP mezipatro | xxx.2310856 | 3.NP mezipatro
2310878 | 3.NP mezipatro | xxx.2310878 | 3.NP mezipatro
2310898 | 3.NP mezipatro | xxx.2310898 | 3.NP mezipatro
2311133 | 1.NP | xxx.2311133 | 1.NP
2311134 | 1.NP | xxx.2311134 | 1.NP
2311165 | 1.NP | xxx.2311165 | 1.NP
2311675 | 1.NP mezipatro | xxx.2311675 | 1.NP mezipatro
2311860 | 1.NP mezipatro | xxx.2311860 | 1.NP mezipatro
2311951 | 1.NP mezipatro | xxx.2311951 | 1.NP mezipatro
2311952 | 1.NP mezipatro | xxx.2311952 | 1.NP mezipatro
2311987 | 1.NP mezipatro | xxx.2311987 | 1.NP mezipatro
2311988 | 1.NP mezipatro | xxx.2311988 | 1.NP mezipatro
2312257 | 1.NP | xxx.2312257 | 1.NP
2312258 | 1.NP | xxx.2312258 | 1.NP
2312286 | 1.NP | xxx.2312286 | 1.NP
2312799 | 1.S mezipatro | xxx.2312799 | 1.S mezipatro
2323862 | 5.NP | xxx.2323862 | 5.NP
2323993 | 5.NP | xxx.2323993 | 5.NP
2324686 | 4.NP | xxx.2324686 | 4.NP
2325352 | 4.NP | xxx.2325352 | 4.NP
2326208 | 5.NP | xxx.2326208 | 5.NP
2328618 | 4.NP mezipatro | xxx.2328618 | 4.NP mezipatro
2329641 | 4.NP mezipatro | xxx.2329641 | 4.NP mezipatro
2331675 | 4.NP mezipatro | xxx.2331675 | 4.NP mezipatro
2332251 | 4.NP | xxx.2332251 | 4.NP
2332714 | 3.NP mezipatro | xxx.2332714 | 3.NP mezipatro
2335331 | 3.NP mezipatro | xxx.2335331 | 3.NP mezipatro
2337105 | 1.S | xxx.2337105 | 1.S
2337113 | 1.S | xxx.2337113 | 1.S
2339777 | 1.S | xxx.2339777 | 1.S
2423870 | 5.NP | xxx.2423870 | 5.NP
2424703 | 1.S mezipatro | xxx.2424703 | 1.S mezipatro
2424735 | 1.S mezipatro | xxx.2424735 | 1.S mezipatro

# IfcCableCarrierFitting: M_Horizontální ohyb kanálu:Standardní (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Ohyb; ElementProjectSpecificIdentifier: xxx; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (M_Horizontální ohyb kanálu:Standardní:...) | Reference
2444429 | xxx.2444429
2444486 | xxx.2444486

# IfcCableCarrierFitting: M_Horizontální spoj T kanálů:Poloměr 300mm (17)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Poloměr 300mm; ElementProjectSpecificDescription: Spoj; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
Name (M_Horizontální spoj T kanálů:Poloměr 300mm:...) | In | Reference | StoreyProjectSpecificIdentifier
1647321 | 1.S | xxx.1647321 | 1.S
1647779 | 1.S | xxx.1647779 | 1.S
1648244 | 1.S | xxx.1648244 | 1.S
1793288 | 5.NP | xxx.1793288 | 5.NP
2300908 | 5.NP | xxx.2300908 | 5.NP
2302122 | 5.NP | xxx.2302122 | 5.NP
2302964 | 4.NP mezipatro | xxx.2302964 | 4.NP mezipatro
2305389 | 4.NP | xxx.2305389 | 4.NP
2306342 | 2.NP | xxx.2306342 | 2.NP
2307003 | 2.NP mezipatro | xxx.2307003 | 2.NP mezipatro
2309589 | 3.NP | xxx.2309589 | 3.NP
2309919 | 3.NP mezipatro | xxx.2309919 | 3.NP mezipatro
2311813 | 1.NP mezipatro | xxx.2311813 | 1.NP mezipatro
2312284 | 1.NP | xxx.2312284 | 1.NP
2312515 | 1.S mezipatro | xxx.2312515 | 1.S mezipatro
2339934 | 1.S | xxx.2339934 | 1.S
2424037 | 5.NP | xxx.2424037 | 5.NP

# IfcCableCarrierFitting: M_Redukce kanálu:Standardní (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Redukce; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - ElementProjectSpecificIdentifier: x1; StoreyProjectSpecificIdentifier: 1.S
Name (M_Redukce kanálu:Standardní:...) | Reference
2337969 | xxx.2337969
2339778 | xxx.2339778

# IfcCableCarrierFitting: M_Vertikální vnitřní ohyb kanálu:Standardní (16)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Ohyb; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
Name (M_Vertikální vnitřní ohyb kanálu:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier
2287768 | 4.NP | xxx.2287768 | 4.NP
2287811 | 4.NP | xxx.2287811 | 4.NP
2290430 | 1.S | xxx.2290430 | 1.S
2326337 | 5.NP | xxx.2326337 | 5.NP
2327786 | 4.NP mezipatro | xxx.2327786 | 4.NP mezipatro
2329910 | 4.NP mezipatro | xxx.2329910 | 4.NP mezipatro
2329913 | 4.NP mezipatro | xxx.2329913 | 4.NP mezipatro
2331507 | 4.NP mezipatro | xxx.2331507 | 4.NP mezipatro
2334974 | 3.NP mezipatro | xxx.2334974 | 3.NP mezipatro
2335315 | 3.NP mezipatro | xxx.2335315 | 3.NP mezipatro
2335473 | 1.S mezipatro | xxx.2335473 | 1.S mezipatro
2335476 | 1.S mezipatro | xxx.2335476 | 1.S mezipatro
2335956 | 2.NP mezipatro | xxx.2335956 | 2.NP mezipatro
2336005 | 2.NP mezipatro | xxx.2336005 | 2.NP mezipatro
2336328 | 1.NP mezipatro | xxx.2336328 | 1.NP mezipatro
2336365 | 1.NP mezipatro | xxx.2336365 | 1.NP mezipatro

# IfcCableCarrierFitting: M_Vertikální vnitřní ohyb kanálu:Standardní, M_Vertikální vnitřní ohyb kanálu:Standardní:2445506
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Ohyb; ElementProjectSpecificIdentifier: xxx; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - Reference: xxx.2445506; StoreyProjectSpecificIdentifier: 1.S

# IfcCableCarrierFitting: M_Vertikální vnější ohyb kanálu:Standardní (20)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Ohyb; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
Name (M_Vertikální vnější ohyb kanálu:Standardní:...) | In | Reference | StoreyProjectSpecificIdentifier
2287778 | 4.NP | xxx.2287778 | 4.NP
2287816 | 4.NP | xxx.2287816 | 4.NP
2325354 | 4.NP | xxx.2325354 | 4.NP
2325357 | 4.NP | xxx.2325357 | 4.NP
2326340 | 5.NP | xxx.2326340 | 5.NP
2329642 | 4.NP mezipatro | xxx.2329642 | 4.NP mezipatro
2329811 | 4.NP mezipatro | xxx.2329811 | 4.NP mezipatro
2329882 | 4.NP mezipatro | xxx.2329882 | 4.NP mezipatro
2331510 | 4.NP mezipatro | xxx.2331510 | 4.NP mezipatro
2332278 | 4.NP | xxx.2332278 | 4.NP
2332280 | 4.NP | xxx.2332280 | 4.NP
2334976 | 3.NP mezipatro | xxx.2334976 | 3.NP mezipatro
2335332 | 3.NP mezipatro | xxx.2335332 | 3.NP mezipatro
2335959 | 2.NP mezipatro | xxx.2335959 | 2.NP mezipatro
2336008 | 2.NP mezipatro | xxx.2336008 | 2.NP mezipatro
2336331 | 1.NP mezipatro | xxx.2336331 | 1.NP mezipatro
2336368 | 1.NP mezipatro | xxx.2336368 | 1.NP mezipatro
2337967 | 1.S | xxx.2337967 | 1.S
2424704 | 1.S mezipatro | xxx.2424704 | 1.S mezipatro
2424736 | 1.S mezipatro | xxx.2424736 | 1.S mezipatro

# IfcCableCarrierFitting: M_Vertikální vnější ohyb kanálu:Standardní, M_Vertikální vnější ohyb kanálu:Standardní:2445509
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: Ohyb; ElementProjectSpecificIdentifier: xxx; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - Reference: xxx.2445509; StoreyProjectSpecificIdentifier: 1.S

# IfcCableCarrierSegment: Kabelová lávka bez tvarovek:Žebříková kabelová lávka (4)
In: 5.NP
Type - PredefinedType: CABLETRAYSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Žebříková kabelová lávka; ElementProjectSpecificDescription: Kabelový žebřík nepožární; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificIdentifier: xxx
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 5.NP
Name (Kabelová lávka bez tvarovek:Žebříková kabelová lávka:...) | Reference | ElementProjectSpecificIdentifier
2259677 | xxx.2259677 | x1
2259679 | xxx.2259679 | x1
2259681 | xxx.2259681 | x1
2456058 | xxx.2456058

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Kabelová lávka s pevným dnem (187)
Type - PredefinedType: CABLETRAYSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Kabelová lávka s pevným dnem; ElementProjectSpecificDescription: Kabelový žlab nepožární; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificIdentifier: xxx
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
Name (Kabelová lávka s tvarovkami:Kabelová lávka s pevným dnem:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1637050 | 2.NP | xxx.1637050 | x1 | 2.NP
1637071 | 2.NP | xxx.1637071 | x1 | 2.NP
1637076 | 2.NP | xxx.1637076 | x1 | 2.NP
1637083 | 2.NP | xxx.1637083 | x1 | 2.NP
1638109 | 2.NP mezipatro | xxx.1638109 | x1 | 2.NP mezipatro
1638119 | 2.NP mezipatro | xxx.1638119 | x1 | 2.NP mezipatro
1638150 | 2.NP mezipatro | xxx.1638150 | x1 | 2.NP mezipatro
1638155 | 2.NP mezipatro | xxx.1638155 | x1 | 2.NP mezipatro
1638176 | 2.NP mezipatro | xxx.1638176 | x1 | 2.NP mezipatro
1638181 | 2.NP mezipatro | xxx.1638181 | x1 | 2.NP mezipatro
1638188 | 2.NP mezipatro | xxx.1638188 | x1 | 2.NP mezipatro
1638692 | 2.NP mezipatro | xxx.1638692 | x1 | 2.NP mezipatro
1638698 | 2.NP mezipatro | xxx.1638698 | x1 | 2.NP mezipatro
1638729 | 2.NP mezipatro | xxx.1638729 | x1 | 2.NP mezipatro
1638734 | 2.NP mezipatro | xxx.1638734 | x1 | 2.NP mezipatro
1646132 | 1.S | xxx.1646132 | x1 | 1.S
1646140 | 1.S | xxx.1646140 | x1 | 1.S
1646156 | 1.S | xxx.1646156 | x1 | 1.S
1647313 | 1.S | xxx.1647313 | x1 | 1.S
1647322 | 1.S | xxx.1647322 | x1 | 1.S
1647774 | 1.S | xxx.1647774 | x1 | 1.S
1647780 | 1.S | xxx.1647780 | x1 | 1.S
1647866 | 1.S | xxx.1647866 | x1 | 1.S
1647871 | 1.S | xxx.1647871 | x1 | 1.S
1648235 | 1.S | xxx.1648235 | x1 | 1.S
1648245 | 1.S | xxx.1648245 | x1 | 1.S
1700578 | 5.NP | xxx.1700578 | x1 | 5.NP
1771390 | 1.S | xxx.1771390 | x1 | 1.S
1792692 | 5.NP | xxx.1792692 | x1 | 5.NP
1793188 | 5.NP | xxx.1793188 | x1 | 5.NP
1793289 | 5.NP | xxx.1793289 | x1 | 5.NP
1794488 | 5.NP | xxx.1794488 | x1 | 5.NP
1794644 | 5.NP | xxx.1794644 | x1 | 5.NP
1795443 | 5.NP | xxx.1795443 | x1 | 5.NP
1799177 | 5.NP | xxx.1799177 | x1 | 5.NP
1801848 | 1.S | xxx.1801848 | x1 | 1.S
2045519 | 2.NP | xxx.2045519 | x1 | 2.NP
2047128 | 3.NP | xxx.2047128 | x1 | 3.NP
2047133 | 3.NP | xxx.2047133 | x1 | 3.NP
2047134 | 3.NP | xxx.2047134 | x1 | 3.NP
2047136 | 3.NP | xxx.2047136 | x1 | 3.NP
2047149 | 3.NP | xxx.2047149 | x1 | 3.NP
2047151 | 3.NP | xxx.2047151 | x1 | 3.NP
2047169 | 3.NP mezipatro | xxx.2047169 | x1 | 3.NP mezipatro
2047171 | 3.NP mezipatro | xxx.2047171 | x1 | 3.NP mezipatro
2047174 | 3.NP mezipatro | xxx.2047174 | x1 | 3.NP mezipatro
2047175 | 3.NP mezipatro | xxx.2047175 | x1 | 3.NP mezipatro
2047177 | 3.NP mezipatro | xxx.2047177 | x1 | 3.NP mezipatro
2047192 | 3.NP mezipatro | xxx.2047192 | x1 | 3.NP mezipatro
2047194 | 3.NP mezipatro | xxx.2047194 | x1 | 3.NP mezipatro
2047207 | 3.NP | xxx.2047207 | x1 | 3.NP
2047458 | 4.NP | xxx.2047458 | x1 | 4.NP
2047462 | 4.NP | xxx.2047462 | x1 | 4.NP
2047464 | 4.NP | xxx.2047464 | x1 | 4.NP
2047477 | 4.NP | xxx.2047477 | x1 | 4.NP
2047486 | 4.NP mezipatro | xxx.2047486 | x1 | 4.NP mezipatro
2047487 | 4.NP mezipatro | xxx.2047487 | x1 | 4.NP mezipatro
2047489 | 4.NP mezipatro | xxx.2047489 | x1 | 4.NP mezipatro
2047503 | 4.NP mezipatro | xxx.2047503 | x1 | 4.NP mezipatro
2047505 | 4.NP mezipatro | xxx.2047505 | x1 | 4.NP mezipatro
2047509 | 4.NP mezipatro | xxx.2047509 | x1 | 4.NP mezipatro
2047510 | 4.NP mezipatro | xxx.2047510 | x1 | 4.NP mezipatro
2047512 | 4.NP mezipatro | xxx.2047512 | x1 | 4.NP mezipatro
2052945 | 1.NP | xxx.2052945 | x1 | 1.NP
2052955 | 1.NP | xxx.2052955 | x1 | 1.NP
2052960 | 1.NP | xxx.2052960 | x1 | 1.NP
2052961 | 1.NP | xxx.2052961 | x1 | 1.NP
2052963 | 1.NP | xxx.2052963 | x1 | 1.NP
2052966 | 1.NP | xxx.2052966 | x1 | 1.NP
2052976 | 1.NP | xxx.2052976 | x1 | 1.NP
2052978 | 1.NP | xxx.2052978 | x1 | 1.NP
2052984 | 1.NP mezipatro | xxx.2052984 | x1 | 1.NP mezipatro
2052985 | 1.NP mezipatro | xxx.2052985 | x1 | 1.NP mezipatro
2052995 | 1.NP mezipatro | xxx.2052995 | x1 | 1.NP mezipatro
2052997 | 1.NP mezipatro | xxx.2052997 | x1 | 1.NP mezipatro
2053000 | 1.NP mezipatro | xxx.2053000 | x1 | 1.NP mezipatro
2053001 | 1.NP mezipatro | xxx.2053001 | x1 | 1.NP mezipatro
2053003 | 1.NP mezipatro | xxx.2053003 | x1 | 1.NP mezipatro
2053007 | 1.NP mezipatro | xxx.2053007 | x1 | 1.NP mezipatro
2053008 | 1.NP mezipatro | xxx.2053008 | x1 | 1.NP mezipatro
2053018 | 1.NP mezipatro | xxx.2053018 | x1 | 1.NP mezipatro
2053020 | 1.NP mezipatro | xxx.2053020 | x1 | 1.NP mezipatro
2233163 | 1.S mezipatro | xxx.2233163 | x1 | 1.S mezipatro
2233164 | 1.S mezipatro | xxx.2233164 | x1 | 1.S mezipatro
2233166 | 1.S mezipatro | xxx.2233166 | x1 | 1.S mezipatro
2233176 | 1.S mezipatro | xxx.2233176 | x1 | 1.S mezipatro
2233179 | 1.S mezipatro | xxx.2233179 | x1 | 1.S mezipatro
2233180 | 1.S mezipatro | xxx.2233180 | x1 | 1.S mezipatro
2233182 | 1.S mezipatro | xxx.2233182 | x1 | 1.S mezipatro
2233269 | 1.S mezipatro | xxx.2233269 | x1 | 1.S mezipatro
2233270 | 1.S mezipatro | xxx.2233270 | x1 | 1.S mezipatro
2233272 | 1.S mezipatro | xxx.2233272 | x1 | 1.S mezipatro
2233286 | 1.S mezipatro | xxx.2233286 | x1 | 1.S mezipatro
2261451 | 5.NP | xxx.2261451 | x1 | 5.NP
2262505 | 5.NP | xxx.2262505 | x1 | 5.NP
2277238 | 5.NP | xxx.2277238 | x1 | 5.NP
2287531 | 4.NP | xxx.2287531 | x1 | 4.NP
2287767 | 4.NP | xxx.2287767 | x1 | 4.NP
2287809 | 4.NP | xxx.2287809 | x1 | 4.NP
2287810 | 4.NP | xxx.2287810 | x1 | 4.NP
2288879 | 4.NP | xxx.2288879 | x1 | 4.NP
2288910 | 4.NP | xxx.2288910 | x1 | 4.NP
2290469 | 1.S | xxx.2290469 | x1 | 1.S
2290495 | 1.S | xxx.2290495 | x1 | 1.S
2291655 | 1.S | xxx.2291655 | x1 | 1.S
2294504 | 1.S mezipatro | xxx.2294504 | x1 | 1.S mezipatro
2299926 | 4.NP mezipatro | xxx.2299926 | x1 | 4.NP mezipatro
2300340 | 5.NP | xxx.2300340 | x1 | 5.NP
2300902 | 5.NP | xxx.2300902 | x1 | 5.NP
2300963 | 5.NP | xxx.2300963 | x1 | 5.NP
2301107 | 5.NP | xxx.2301107 | x1 | 5.NP
2301190 | 5.NP | xxx.2301190 | x1 | 5.NP
2302123 | 5.NP | xxx.2302123 | x1 | 5.NP
2302822 | 4.NP mezipatro | xxx.2302822 | x1 | 4.NP mezipatro
2302823 | 4.NP mezipatro | xxx.2302823 | x1 | 4.NP mezipatro
2302965 | 4.NP mezipatro | xxx.2302965 | x1 | 4.NP mezipatro
2303325 | 4.NP | xxx.2303325 | x1 | 4.NP
2304445 | 3.NP | xxx.2304445 | x1 | 3.NP
2304470 | 3.NP | xxx.2304470 | x1 | 3.NP
2304854 | 3.NP | xxx.2304854 | x1 | 3.NP
2305291 | 4.NP | xxx.2305291 | x1 | 4.NP
2305390 | 4.NP | xxx.2305390 | x1 | 4.NP
2305779 | 2.NP | xxx.2305779 | x1 | 2.NP
2305869 | 2.NP | xxx.2305869 | x1 | 2.NP
2305880 | 2.NP | xxx.2305880 | x1 | 2.NP
2306128 | 2.NP | xxx.2306128 | x1 | 2.NP
2306135 | 2.NP | xxx.2306135 | x1 | 2.NP
2306343 | 2.NP | xxx.2306343 | x1 | 2.NP
2306974 | 2.NP mezipatro | xxx.2306974 | x1 | 2.NP mezipatro
2307004 | 2.NP mezipatro | xxx.2307004 | x1 | 2.NP mezipatro
2309590 | 3.NP | xxx.2309590 | x1 | 3.NP
2309780 | 3.NP mezipatro | xxx.2309780 | x1 | 3.NP mezipatro
2309920 | 3.NP mezipatro | xxx.2309920 | x1 | 3.NP mezipatro
2310504 | 4.NP | xxx.2310504 | x1 | 4.NP
2310815 | 3.NP mezipatro | xxx.2310815 | x1 | 3.NP mezipatro
2310821 | 3.NP mezipatro | xxx.2310821 | x1 | 3.NP mezipatro
2310868 | 3.NP mezipatro | xxx.2310868 | x1 | 3.NP mezipatro
2310874 | 3.NP mezipatro | xxx.2310874 | x1 | 3.NP mezipatro
2311383 | 1.NP | xxx.2311383 | x1 | 1.NP
2311429 | 1.NP | xxx.2311429 | x1 | 1.NP
2311674 | 1.NP mezipatro | xxx.2311674 | x1 | 1.NP mezipatro
2311814 | 1.NP mezipatro | xxx.2311814 | x1 | 1.NP mezipatro
2312285 | 1.NP | xxx.2312285 | x1 | 1.NP
2312516 | 1.S mezipatro | xxx.2312516 | x1 | 1.S mezipatro
2325132 | 4.NP | xxx.2325132 | x1 | 4.NP
2325191 | 4.NP | xxx.2325191 | x1 | 4.NP
2325349 | 4.NP | xxx.2325349 | x1 | 4.NP
2326121 | 5.NP | xxx.2326121 | x1 | 5.NP
2326207 | 5.NP | xxx.2326207 | x1 | 5.NP
2327158 | 4.NP mezipatro | xxx.2327158 | x1 | 4.NP mezipatro
2327589 | 4.NP mezipatro | xxx.2327589 | x1 | 4.NP mezipatro
2328513 | 4.NP mezipatro | xxx.2328513 | x1 | 4.NP mezipatro
2328534 | 4.NP mezipatro | xxx.2328534 | x1 | 4.NP mezipatro
2329783 | 4.NP mezipatro | xxx.2329783 | x1 | 4.NP mezipatro
2329857 | 4.NP mezipatro | xxx.2329857 | x1 | 4.NP mezipatro
2329977 | 4.NP mezipatro | xxx.2329977 | x1 | 4.NP mezipatro
2331246 | 4.NP mezipatro | xxx.2331246 | x1 | 4.NP mezipatro
2331668 | 4.NP mezipatro | xxx.2331668 | x1 | 4.NP mezipatro
2332227 | 4.NP | xxx.2332227 | x1 | 4.NP
2332250 | 4.NP | xxx.2332250 | x1 | 4.NP
2334370 | 3.NP mezipatro | xxx.2334370 | x1 | 3.NP mezipatro
2334402 | 3.NP mezipatro | xxx.2334402 | x1 | 3.NP mezipatro
2334794 | 3.NP mezipatro | xxx.2334794 | x1 | 3.NP mezipatro
2335025 | 3.NP mezipatro | xxx.2335025 | x1 | 3.NP mezipatro
2335380 | 2.NP mezipatro | xxx.2335380 | x1 | 2.NP mezipatro
2335381 | 2.NP mezipatro | xxx.2335381 | x1 | 2.NP mezipatro
2335384 | 2.NP mezipatro | xxx.2335384 | x1 | 2.NP mezipatro
2335412 | 1.NP mezipatro | xxx.2335412 | x1 | 1.NP mezipatro
2335413 | 1.NP mezipatro | xxx.2335413 | x1 | 1.NP mezipatro
2335416 | 1.NP mezipatro | xxx.2335416 | x1 | 1.NP mezipatro
2335471 | 1.S mezipatro | xxx.2335471 | x1 | 1.S mezipatro
2335472 | 1.S mezipatro | xxx.2335472 | x1 | 1.S mezipatro
2335475 | 1.S mezipatro | xxx.2335475 | x1 | 1.S mezipatro
2335701 | 2.NP mezipatro | xxx.2335701 | x1 | 2.NP mezipatro
2336143 | 1.NP mezipatro | xxx.2336143 | x1 | 1.NP mezipatro
2337095 | 1.S | xxx.2337095 | x1 | 1.S
2337107 | 1.S | xxx.2337107 | x1 | 1.S
2337964 | 1.S | xxx.2337964 | x1 | 1.S
2338470 | 4.NP | xxx.2338470 | x1 | 4.NP
2338791 | 1.S | xxx.2338791 | x1 | 1.S
2339935 | 1.S | xxx.2339935 | x1 | 1.S
2340113 | 1.S | xxx.2340113 | x1 | 1.S
2424038 | 5.NP | xxx.2424038 | x1 | 5.NP
2424511 | 1.S mezipatro | xxx.2424511 | x1 | 1.S mezipatro
2444417 | 1.S | xxx.2444417 |  | 1.S
2444453 | 1.S | xxx.2444453 |  | 1.S
2445215 | 1.S | xxx.2445215 |  | 1.S

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Žebříková kabelová lávka (3)
Type - PredefinedType: CABLETRAYSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Žebříková kabelová lávka; ElementProjectSpecificDescription: Kabelový žebřík nepožární; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové trasy a nosný systém pro kabely ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
Name (Kabelová lávka s tvarovkami:Žebříková kabelová lávka:...) | In | Reference | StoreyProjectSpecificIdentifier
1794694 | 5.NP | xxx.1794694 | 5.NP
2053024 | 1.S | xxx.2053024 | 1.S
2053025 | 1.S | xxx.2053025 | 1.S

# IfcDistributionPort (1650)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | PredefinedType | SystemType
Port_1231466_1 | CABLE | ELECTRICAL
Port_1231523_1 | CABLE | ELECTRICAL
Port_1231954_1 | CABLE | ELECTRICAL
Port_1231955_1 | CABLE | ELECTRICAL
Port_1232193_1 | CABLE | ELECTRICAL
Port_1232194_1 | CABLE | ELECTRICAL
Port_1232510_1 | CABLE | ELECTRICAL
Port_1232512_1 | CABLE | ELECTRICAL
Port_1232513_1 | CABLE | ELECTRICAL
Port_1232514_1 | CABLE | ELECTRICAL
Port_1233032_1 | CABLE | ELECTRICAL
Port_1233035_1 | CABLE | ELECTRICAL
Port_1233036_1 | CABLE | ELECTRICAL
Port_1233243_1 | CABLE | ELECTRICAL
Port_1233245_1 | CABLE | ELECTRICAL
Port_1233246_1 | CABLE | ELECTRICAL
Port_1233247_1 | CABLE | ELECTRICAL
Port_1233335_1 | CABLE | ELECTRICAL
Port_1233337_1 | CABLE | ELECTRICAL
Port_1233461_1 | CABLE | ELECTRICAL
Port_1233463_1 | CABLE | ELECTRICAL
Port_1233464_1 | CABLE | ELECTRICAL
Port_1233465_1 | CABLE | ELECTRICAL
Port_1240184_1 | CABLE | ELECTRICAL
Port_1240203_1 | CABLE | ELECTRICAL
Port_1240230_1 | CABLE | ELECTRICAL
Port_1240240_1 | CABLE | ELECTRICAL
Port_1251818_1 | CABLE | ELECTRICAL
Port_1251826_1 | CABLE | ELECTRICAL
Port_1263481_1 | CABLE | ELECTRICAL
Port_1264438_1 | CABLE | ELECTRICAL
Port_1264485_1 | CABLE | ELECTRICAL
Port_1264708_1 | CABLE | ELECTRICAL
Port_1264834_1 | CABLE | ELECTRICAL
Port_1267365_1 | CABLE | ELECTRICAL
Port_1267414_1 | CABLE | ELECTRICAL
Port_1268014_1 | CABLE | ELECTRICAL
Port_1271215_1 | CABLE | ELECTRICAL
Port_1271269_1 | CABLE | ELECTRICAL
Port_1271709_1 | CABLE | ELECTRICAL
Port_1271718_1 | CABLE | ELECTRICAL
Port_1271728_1 | CABLE | ELECTRICAL
Port_1271738_1 | CABLE | ELECTRICAL
Port_1271744_1 | CABLE | ELECTRICAL
Port_1271754_1 | CABLE | ELECTRICAL
Port_1271762_1 | CABLE | ELECTRICAL
Port_1274165_1 | CABLE | ELECTRICAL
Port_1274307_1 | CABLE | ELECTRICAL
Port_1594028_1 | CABLE | ELECTRICAL
Port_1594316_1 | CABLE | ELECTRICAL
Port_1594341_1 | CABLE | ELECTRICAL
Port_1594358_1 | CABLE | ELECTRICAL
Port_1594372_1 | CABLE | ELECTRICAL
Port_1594382_1 | CABLE | ELECTRICAL
Port_1594394_1 | CABLE | ELECTRICAL
Port_1594406_1 | CABLE | ELECTRICAL
Port_1594418_1 | CABLE | ELECTRICAL
Port_1594771_1 | CABLE | ELECTRICAL
Port_1594866_1 | CABLE | ELECTRICAL
Port_1594905_1 | CABLE | ELECTRICAL
Port_1595022_1 | CABLE | ELECTRICAL
Port_1595067_1 | CABLE | ELECTRICAL
Port_1595088_1 | CABLE | ELECTRICAL
Port_1595098_1 | CABLE | ELECTRICAL
Port_1595108_1 | CABLE | ELECTRICAL
Port_1595120_1 | CABLE | ELECTRICAL
Port_1595132_1 | CABLE | ELECTRICAL
Port_1595146_1 | CABLE | ELECTRICAL
Port_1595240_1 | CABLE | ELECTRICAL
Port_1595642_1 | CABLE | ELECTRICAL
Port_1595978_1 | CABLE | ELECTRICAL
Port_1596385_1 | CABLE | ELECTRICAL
Port_1598872_1 | CABLE | ELECTRICAL
Port_1599027_1 | CABLE | ELECTRICAL
Port_1599061_1 | CABLE | ELECTRICAL
Port_1599075_1 | CABLE | ELECTRICAL
Port_1599089_1 | CABLE | ELECTRICAL
Port_1599099_1 | CABLE | ELECTRICAL
Port_1599107_1 | CABLE | ELECTRICAL
Port_1599119_1 | CABLE | ELECTRICAL
Port_1599197_1 | CABLE | ELECTRICAL
Port_1599273_1 | CABLE | ELECTRICAL
Port_1599308_1 | CABLE | ELECTRICAL
Port_1599320_1 | CABLE | ELECTRICAL
Port_1599334_1 | CABLE | ELECTRICAL
Port_1599366_1 | CABLE | ELECTRICAL
Port_1599378_1 | CABLE | ELECTRICAL
Port_1599392_1 | CABLE | ELECTRICAL
Port_1599750_1 | CABLE | ELECTRICAL
Port_1599751_1 | CABLE | ELECTRICAL
Port_1599764_1 | CABLE | ELECTRICAL
Port_1599777_1 | CABLE | ELECTRICAL
Port_1608109_1 | CABLE | ELECTRICAL
Port_1608111_1 | CABLE | ELECTRICAL
Port_1608136_1 | CABLE | ELECTRICAL
Port_1608137_1 | CABLE | ELECTRICAL
Port_1608217_1 | CABLE | ELECTRICAL
Port_1608218_1 | CABLE | ELECTRICAL
Port_1608304_1 | CABLE | ELECTRICAL
Port_1608305_1 | CABLE | ELECTRICAL
Port_1608382_1 | CABLE | ELECTRICAL
Port_1608621_1 | CABLE | ELECTRICAL
Port_1608623_1 | CABLE | ELECTRICAL
Port_1608673_1 | CABLE | ELECTRICAL
Port_1608674_1 | CABLE | ELECTRICAL
Port_1608752_1 | CABLE | ELECTRICAL
Port_1608753_1 | CABLE | ELECTRICAL
Port_1608806_1 | CABLE | ELECTRICAL
Port_1608807_1 | CABLE | ELECTRICAL
Port_1608902_1 | CABLE | ELECTRICAL
Port_1608903_1 | CABLE | ELECTRICAL
Port_1609587_1 | CABLE | ELECTRICAL
Port_1609803_1 | CABLE | ELECTRICAL
Port_1609853_1 | CABLE | ELECTRICAL
Port_1609869_1 | CABLE | ELECTRICAL
Port_1610437_1 | CABLE | ELECTRICAL
Port_1610548_1 | CABLE | ELECTRICAL
Port_1610942_1 | CABLE | ELECTRICAL
Port_1610951_1 | CABLE | ELECTRICAL
Port_1610963_1 | CABLE | ELECTRICAL
Port_1610975_1 | CABLE | ELECTRICAL
Port_1610987_1 | CABLE | ELECTRICAL
Port_1610995_1 | CABLE | ELECTRICAL
Port_1611007_1 | CABLE | ELECTRICAL
Port_1611229_1 | CABLE | ELECTRICAL
Port_1612096_1 | CABLE | ELECTRICAL
Port_1612111_1 | CABLE | ELECTRICAL
Port_1612119_1 | CABLE | ELECTRICAL
Port_1612135_1 | CABLE | ELECTRICAL
Port_1612149_1 | CABLE | ELECTRICAL
Port_1612177_1 | CABLE | ELECTRICAL
Port_1612191_1 | CABLE | ELECTRICAL
Port_1612201_1 | CABLE | ELECTRICAL
Port_1612225_1 | CABLE | ELECTRICAL
Port_1612281_1 | CABLE | ELECTRICAL
Port_1612292_1 | CABLE | ELECTRICAL
Port_1612308_1 | CABLE | ELECTRICAL
Port_1612324_1 | CABLE | ELECTRICAL
Port_1612591_1 | CABLE | ELECTRICAL
Port_1617693_1 | CABLE | ELECTRICAL
Port_1619393_1 | CABLE | ELECTRICAL
Port_1619801_1 | CABLE | ELECTRICAL
Port_1625320_1 | CABLE | ELECTRICAL
Port_1627385_1 | CABLE | ELECTRICAL
Port_1627600_1 | CABLE | ELECTRICAL
Port_1627893_1 | CABLE | ELECTRICAL
Port_1627916_1 | CABLE | ELECTRICAL
Port_1628134_1 | CABLE | ELECTRICAL
Port_1628135_1 | CABLE | ELECTRICAL
Port_1628161_1 | CABLE | ELECTRICAL
Port_1628162_1 | CABLE | ELECTRICAL
Port_1628188_1 | CABLE | ELECTRICAL
Port_1628213_1 | CABLE | ELECTRICAL
Port_1628214_1 | CABLE | ELECTRICAL
Port_1628233_1 | CABLE | ELECTRICAL
Port_1628234_1 | CABLE | ELECTRICAL
Port_1630006_1 | CABLE | ELECTRICAL
Port_1630048_1 | CABLE | ELECTRICAL
Port_1630731_1 | CABLE | ELECTRICAL
Port_1630748_1 | CABLE | ELECTRICAL
Port_1630762_1 | CABLE | ELECTRICAL
Port_1630778_1 | CABLE | ELECTRICAL
Port_1631663_1 | CABLE | ELECTRICAL
Port_1631696_1 | CABLE | ELECTRICAL
Port_1631710_1 | CABLE | ELECTRICAL
Port_1631724_1 | CABLE | ELECTRICAL
Port_1631795_1 | CABLE | ELECTRICAL
Port_1631863_1 | CABLE | ELECTRICAL
Port_1631873_1 | CABLE | ELECTRICAL
Port_1631881_1 | CABLE | ELECTRICAL
Port_1631893_1 | CABLE | ELECTRICAL
Port_1631905_1 | CABLE | ELECTRICAL
Port_1631915_1 | CABLE | ELECTRICAL
Port_1631927_1 | CABLE | ELECTRICAL
Port_1631939_1 | CABLE | ELECTRICAL
Port_1632005_1 | CABLE | ELECTRICAL
Port_1632059_1 | CABLE | ELECTRICAL
Port_1632134_1 | CABLE | ELECTRICAL
Port_1632192_1 | CABLE | ELECTRICAL
Port_1632204_1 | CABLE | ELECTRICAL
Port_1632218_1 | CABLE | ELECTRICAL
Port_1632236_1 | CABLE | ELECTRICAL
Port_1632341_1 | CABLE | ELECTRICAL
Port_1632406_1 | CABLE | ELECTRICAL
Port_1632414_1 | CABLE | ELECTRICAL
Port_1632422_1 | CABLE | ELECTRICAL
Port_1632434_1 | CABLE | ELECTRICAL
Port_1632446_1 | CABLE | ELECTRICAL
Port_1632458_1 | CABLE | ELECTRICAL
Port_1632466_1 | CABLE | ELECTRICAL
Port_1632476_1 | CABLE | ELECTRICAL
Port_1632492_1 | CABLE | ELECTRICAL
Port_1632502_1 | CABLE | ELECTRICAL
Port_1632520_1 | CABLE | ELECTRICAL
Port_1632721_1 | CABLE | ELECTRICAL
Port_1632734_1 | CABLE | ELECTRICAL
Port_1632746_1 | CABLE | ELECTRICAL
Port_1632764_1 | CABLE | ELECTRICAL
Port_1632774_1 | CABLE | ELECTRICAL
Port_1632790_1 | CABLE | ELECTRICAL
Port_1632798_1 | CABLE | ELECTRICAL
Port_1632808_1 | CABLE | ELECTRICAL
Port_1632840_1 | CABLE | ELECTRICAL
Port_1632848_1 | CABLE | ELECTRICAL
Port_1632858_1 | CABLE | ELECTRICAL
Port_1632866_1 | CABLE | ELECTRICAL
Port_1632878_1 | CABLE | ELECTRICAL
Port_1632908_1 | CABLE | ELECTRICAL
Port_1632918_1 | CABLE | ELECTRICAL
Port_1632930_1 | CABLE | ELECTRICAL
Port_1633158_1 | CABLE | ELECTRICAL
Port_1633224_1 | CABLE | ELECTRICAL
Port_1633263_1 | CABLE | ELECTRICAL
Port_1633280_1 | CABLE | ELECTRICAL
Port_1633298_1 | CABLE | ELECTRICAL
Port_1633971_1 | CABLE | ELECTRICAL
Port_1633982_1 | CABLE | ELECTRICAL
Port_1634000_1 | CABLE | ELECTRICAL
Port_1634014_1 | CABLE | ELECTRICAL
Port_1634030_1 | CABLE | ELECTRICAL
Port_1634038_1 | CABLE | ELECTRICAL
Port_1634050_1 | CABLE | ELECTRICAL
Port_1634062_1 | CABLE | ELECTRICAL
Port_1634080_1 | CABLE | ELECTRICAL
Port_1634094_1 | CABLE | ELECTRICAL
Port_1634102_1 | CABLE | ELECTRICAL
Port_1634112_1 | CABLE | ELECTRICAL
Port_1634193_1 | CABLE | ELECTRICAL
Port_1634257_1 | CABLE | ELECTRICAL
Port_1634271_1 | CABLE | ELECTRICAL
Port_1634439_1 | CABLE | ELECTRICAL
Port_1634457_1 | CABLE | ELECTRICAL
Port_1634465_1 | CABLE | ELECTRICAL
Port_1634482_1 | CABLE | ELECTRICAL
Port_1634496_1 | CABLE | ELECTRICAL
Port_1634504_1 | CABLE | ELECTRICAL
Port_1634514_1 | CABLE | ELECTRICAL
Port_1634526_1 | CABLE | ELECTRICAL
Port_1634534_1 | CABLE | ELECTRICAL
Port_1634548_1 | CABLE | ELECTRICAL
Port_1634564_1 | CABLE | ELECTRICAL
Port_1634578_1 | CABLE | ELECTRICAL
Port_1634590_1 | CABLE | ELECTRICAL
Port_1634606_1 | CABLE | ELECTRICAL
Port_1634614_1 | CABLE | ELECTRICAL
Port_1634733_1 | CABLE | ELECTRICAL
Port_1634742_1 | CABLE | ELECTRICAL
Port_1634756_1 | CABLE | ELECTRICAL
Port_1634794_1 | CABLE | ELECTRICAL
Port_1634808_1 | CABLE | ELECTRICAL
Port_1634820_1 | CABLE | ELECTRICAL
Port_1634828_1 | CABLE | ELECTRICAL
Port_1634838_1 | CABLE | ELECTRICAL
Port_1634850_1 | CABLE | ELECTRICAL
Port_1634858_1 | CABLE | ELECTRICAL
Port_1634868_1 | CABLE | ELECTRICAL
Port_1634876_1 | CABLE | ELECTRICAL
Port_1634890_1 | CABLE | ELECTRICAL
Port_1634916_1 | CABLE | ELECTRICAL
Port_1634930_1 | CABLE | ELECTRICAL
Port_1635050_1 | CABLE | ELECTRICAL
Port_1635067_1 | CABLE | ELECTRICAL
Port_1635079_1 | CABLE | ELECTRICAL
Port_1635089_1 | CABLE | ELECTRICAL
Port_1635099_1 | CABLE | ELECTRICAL
Port_1635107_1 | CABLE | ELECTRICAL
Port_1635119_1 | CABLE | ELECTRICAL
Port_1635131_1 | CABLE | ELECTRICAL
Port_1635141_1 | CABLE | ELECTRICAL
Port_1635155_1 | CABLE | ELECTRICAL
Port_1635163_1 | CABLE | ELECTRICAL
Port_1635177_1 | CABLE | ELECTRICAL
Port_1635185_1 | CABLE | ELECTRICAL
Port_1635209_1 | CABLE | ELECTRICAL
Port_1635246_1 | CABLE | ELECTRICAL
Port_1637050_0 | CABLECARRIER | CONVEYING
Port_2306637_1 | CABLECARRIER | CONVEYING
Port_1637050_1 | CABLECARRIER | CONVEYING
Port_1637071_0 | CABLECARRIER | CONVEYING
Port_2306342_1 | CABLECARRIER | CONVEYING
Port_1637071_1 | CABLECARRIER | CONVEYING
Port_2306637_2 | CABLECARRIER | CONVEYING
Port_1637076_0 | CABLECARRIER | CONVEYING
Port_2305781_1 | CABLECARRIER | CONVEYING
Port_1637076_1 | CABLECARRIER | CONVEYING
Port_1637089_2 | CABLECARRIER | CONVEYING
Port_1637083_0 | CABLECARRIER | CONVEYING
Port_1637089_1 | CABLECARRIER | CONVEYING
Port_1637083_1 | CABLECARRIER | CONVEYING
Port_1638109_0 | CABLECARRIER | CONVEYING
Port_1638109_1 | CABLECARRIER | CONVEYING
Port_1638125_1 | CABLECARRIER | CONVEYING
Port_1638119_0 | CABLECARRIER | CONVEYING
Port_1638125_2 | CABLECARRIER | CONVEYING
Port_1638119_1 | CABLECARRIER | CONVEYING
Port_2308195_2 | CABLECARRIER | CONVEYING
Port_1638150_0 | CABLECARRIER | CONVEYING
Port_2336008_1 | CABLECARRIER | CONVEYING
Port_1638150_1 | CABLECARRIER | CONVEYING
Port_2308195_1 | CABLECARRIER | CONVEYING
Port_1638155_0 | CABLECARRIER | CONVEYING
Port_2308194_1 | CABLECARRIER | CONVEYING
Port_1638155_1 | CABLECARRIER | CONVEYING
Port_2307003_3 | CABLECARRIER | CONVEYING
Port_1638176_0 | CABLECARRIER | CONVEYING
Port_2307003_2 | CABLECARRIER | CONVEYING
Port_1638176_1 | CABLECARRIER | CONVEYING
Port_2306980_1 | CABLECARRIER | CONVEYING
Port_1638181_0 | CABLECARRIER | CONVEYING
Port_1638187_2 | CABLECARRIER | CONVEYING
Port_1638181_1 | CABLECARRIER | CONVEYING
Port_1638192_1 | CABLECARRIER | CONVEYING
Port_1638187_1 | CABLECARRIER | CONVEYING
Port_2307004_0 | CABLECARRIER | CONVEYING
Port_1638188_0 | CABLECARRIER | CONVEYING
Port_1638192_2 | CABLECARRIER | CONVEYING
Port_1638188_1 | CABLECARRIER | CONVEYING
Port_1638692_0 | CABLECARRIER | CONVEYING
Port_1638692_1 | CABLECARRIER | CONVEYING
Port_1638704_1 | CABLECARRIER | CONVEYING
Port_1638698_0 | CABLECARRIER | CONVEYING
Port_1638704_2 | CABLECARRIER | CONVEYING
Port_1638698_1 | CABLECARRIER | CONVEYING
Port_2308140_2 | CABLECARRIER | CONVEYING
Port_1638729_0 | CABLECARRIER | CONVEYING
Port_2308139_2 | CABLECARRIER | CONVEYING
Port_1638729_1 | CABLECARRIER | CONVEYING
Port_2308140_1 | CABLECARRIER | CONVEYING
Port_1638734_0 | CABLECARRIER | CONVEYING
Port_2308139_1 | CABLECARRIER | CONVEYING
Port_1638734_1 | CABLECARRIER | CONVEYING
Port_1639527_1 | CABLE | ELECTRICAL
Port_1639544_1 | CABLE | ELECTRICAL
Port_1639556_1 | CABLE | ELECTRICAL
Port_1639566_1 | CABLE | ELECTRICAL
Port_1639578_1 | CABLE | ELECTRICAL
Port_1639586_1 | CABLE | ELECTRICAL
Port_1639606_1 | CABLE | ELECTRICAL
Port_1639620_1 | CABLE | ELECTRICAL
Port_1639634_1 | CABLE | ELECTRICAL
Port_1639650_1 | CABLE | ELECTRICAL
Port_1639662_1 | CABLE | ELECTRICAL
Port_1639782_1 | CABLE | ELECTRICAL
Port_1639846_1 | CABLE | ELECTRICAL
Port_1639856_1 | CABLE | ELECTRICAL
Port_1639864_1 | CABLE | ELECTRICAL
Port_1639874_1 | CABLE | ELECTRICAL
Port_1639884_1 | CABLE | ELECTRICAL
Port_1639894_1 | CABLE | ELECTRICAL
Port_1639904_1 | CABLE | ELECTRICAL
Port_1639920_1 | CABLE | ELECTRICAL
Port_1639939_1 | CABLE | ELECTRICAL
Port_1639947_1 | CABLE | ELECTRICAL
Port_1639959_1 | CABLE | ELECTRICAL
Port_1639967_1 | CABLE | ELECTRICAL
Port_1639981_1 | CABLE | ELECTRICAL
Port_1639997_1 | CABLE | ELECTRICAL
Port_1640007_1 | CABLE | ELECTRICAL
Port_1646132_0 | CABLECARRIER | CONVEYING
Port_1646149_2 | CABLECARRIER | CONVEYING
Port_1646132_1 | CABLECARRIER | CONVEYING
Port_1646140_0 | CABLECARRIER | CONVEYING
Port_1646149_1 | CABLECARRIER | CONVEYING
Port_1646140_1 | CABLECARRIER | CONVEYING
Port_2339777_2 | CABLECARRIER | CONVEYING
Port_1646156_0 | CABLECARRIER | CONVEYING
Port_1647779_1 | CABLECARRIER | CONVEYING
Port_1646156_1 | CABLECARRIER | CONVEYING
Port_2053025_2 | CABLECARRIER | CONVEYING
Port_1647313_0 | CABLECARRIER | CONVEYING
Port_1647321_3 | CABLECARRIER | CONVEYING
Port_1647313_1 | CABLECARRIER | CONVEYING
Port_1647321_1 | CABLECARRIER | CONVEYING
Port_1647322_0 | CABLECARRIER | CONVEYING
Port_1647321_2 | CABLECARRIER | CONVEYING
Port_2340113_0 | CABLECARRIER | CONVEYING
Port_1647322_1 | CABLECARRIER | CONVEYING
Port_2339934_3 | CABLECARRIER | CONVEYING
Port_1647774_0 | CABLECARRIER | CONVEYING
Port_1647779_3 | CABLECARRIER | CONVEYING
Port_1647774_1 | CABLECARRIER | CONVEYING
Port_2290475_2 | CABLECARRIER | CONVEYING
Port_1647779_2 | CABLECARRIER | CONVEYING
Port_1647780_0 | CABLECARRIER | CONVEYING
Port_1647780_1 | CABLECARRIER | CONVEYING
Port_1647866_0 | CABLECARRIER | CONVEYING
Port_2337105_1 | CABLECARRIER | CONVEYING
Port_1647866_1 | CABLECARRIER | CONVEYING
Port_1647881_2 | CABLECARRIER | CONVEYING
Port_1647871_0 | CABLECARRIER | CONVEYING
Port_1648244_1 | CABLECARRIER | CONVEYING
Port_1647871_1 | CABLECARRIER | CONVEYING
Port_2445506_1 | CABLECARRIER | CONVEYING
Port_1647881_1 | CABLECARRIER | CONVEYING
Port_1648245_0 | CABLECARRIER | CONVEYING
Port_1648235_0 | CABLECARRIER | CONVEYING
Port_2290430_2 | CABLECARRIER | CONVEYING
Port_1648235_1 | CABLECARRIER | CONVEYING
Port_2290503_2 | CABLECARRIER | CONVEYING
Port_1648244_2 | CABLECARRIER | CONVEYING
Port_1648245_1 | CABLECARRIER | CONVEYING
Port_1648244_3 | CABLECARRIER | CONVEYING
Port_2337964_0 | CABLECARRIER | CONVEYING
Port_1658646_1 | CABLE | ELECTRICAL
Port_1659258_1 | CABLE | ELECTRICAL
Port_1659332_1 | CABLE | ELECTRICAL
Port_1659353_1 | CABLE | ELECTRICAL
Port_1659365_1 | CABLE | ELECTRICAL
Port_1659377_1 | CABLE | ELECTRICAL
Port_1659393_1 | CABLE | ELECTRICAL
Port_1659401_1 | CABLE | ELECTRICAL
Port_1659503_1 | CABLE | ELECTRICAL
Port_1659517_1 | CABLE | ELECTRICAL
Port_1659659_1 | CABLE | ELECTRICAL
Port_1659904_1 | CABLE | ELECTRICAL
Port_1659915_1 | CABLE | ELECTRICAL
Port_1659927_1 | CABLE | ELECTRICAL
Port_1659941_1 | CABLE | ELECTRICAL
Port_1659955_1 | CABLE | ELECTRICAL
Port_1659971_1 | CABLE | ELECTRICAL
Port_1659989_1 | CABLE | ELECTRICAL
Port_1660080_1 | CABLE | ELECTRICAL
Port_1660099_1 | CABLE | ELECTRICAL
Port_1661280_1 | CABLE | ELECTRICAL
Port_1661919_1 | CABLE | ELECTRICAL
Port_1661948_1 | CABLE | ELECTRICAL
Port_1661956_1 | CABLE | ELECTRICAL
Port_1666376_1 | CABLE | ELECTRICAL
Port_1666492_1 | CABLE | ELECTRICAL
Port_1669432_1 | CABLE | ELECTRICAL
Port_1669580_1 | CABLE | ELECTRICAL
Port_1669961_1 | CABLE | ELECTRICAL
Port_1670276_1 | CABLE | ELECTRICAL
Port_1670714_1 | CABLE | ELECTRICAL
Port_1671023_1 | CABLE | ELECTRICAL
Port_1671269_1 | CABLE | ELECTRICAL
Port_1675168_1 | CABLE | ELECTRICAL
Port_1675368_1 | CABLE | ELECTRICAL
Port_1675629_1 | CABLE | ELECTRICAL
Port_1675851_1 | CABLE | ELECTRICAL
Port_1675864_1 | CABLE | ELECTRICAL
Port_1675876_1 | CABLE | ELECTRICAL
Port_1675892_1 | CABLE | ELECTRICAL
Port_1675904_1 | CABLE | ELECTRICAL
Port_1675916_1 | CABLE | ELECTRICAL
Port_1675928_1 | CABLE | ELECTRICAL
Port_1676006_1 | CABLE | ELECTRICAL
Port_1676018_1 | CABLE | ELECTRICAL
Port_1676123_1 | CABLE | ELECTRICAL
Port_1676134_1 | CABLE | ELECTRICAL
Port_1676144_1 | CABLE | ELECTRICAL
Port_1676154_1 | CABLE | ELECTRICAL
Port_1676168_1 | CABLE | ELECTRICAL
Port_1676184_1 | CABLE | ELECTRICAL
Port_1676194_1 | CABLE | ELECTRICAL
Port_1676293_1 | CABLE | ELECTRICAL
Port_1676313_1 | CABLE | ELECTRICAL
Port_1677512_1 | CABLE | ELECTRICAL
Port_1677545_1 | CABLE | ELECTRICAL
Port_1677559_1 | CABLE | ELECTRICAL
Port_1677567_1 | CABLE | ELECTRICAL
Port_1677577_1 | CABLE | ELECTRICAL
Port_1677589_1 | CABLE | ELECTRICAL
Port_1677603_1 | CABLE | ELECTRICAL
Port_1677723_1 | CABLE | ELECTRICAL
Port_1678468_1 | CABLE | ELECTRICAL
Port_1679065_1 | CABLE | ELECTRICAL
Port_1679490_1 | CABLE | ELECTRICAL
Port_1681613_1 | CABLE | ELECTRICAL
Port_1685267_1 | CABLE | ELECTRICAL
Port_1685557_1 | CABLE | ELECTRICAL
Port_1697694_1 | CABLE | ELECTRICAL
Port_1697805_1 | CABLE | ELECTRICAL
Port_1697866_1 | CABLE | ELECTRICAL
Port_1697867_1 | CABLE | ELECTRICAL
Port_1697931_1 | CABLE | ELECTRICAL
Port_1699259_1 | CABLE | ELECTRICAL
Port_1699261_1 | CABLE | ELECTRICAL
Port_1699291_1 | CABLE | ELECTRICAL
Port_1699334_1 | CABLE | ELECTRICAL
Port_1699336_1 | CABLE | ELECTRICAL
Port_1699410_1 | CABLE | ELECTRICAL
Port_1699411_1 | CABLE | ELECTRICAL
Port_1700578_0 | CABLECARRIER | CONVEYING
Port_2323993_1 | CABLECARRIER | CONVEYING
Port_1700578_1 | CABLECARRIER | CONVEYING
Port_1705825_1 | CABLE | ELECTRICAL
