Properties of the parts of a building model (IFC4), part 3 of 3

# IfcLightFixture: Nouzové světlo N5:NS_N5 (135)
Name (Nouzové světlo N5:NS_N5:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1677577 | 4.NP mezipatro | N5.1677577 | N | 4.NP mezipatro | RPO-N4.01
1677589 | 4.NP mezipatro | N5.1677589 | N | 4.NP mezipatro | RPO-N4.01
1677603 | 4.NP mezipatro | N5.1677603 | N1 | 4.NP mezipatro | RPO-N0.01
1677723 | 4.NP mezipatro | N5.1677723 | N1 | 4.NP mezipatro | RPO-N0.02
1679065 | 3.NP mezipatro | N5.1679065 | N1 | 3.NP mezipatro | RPO-N3.01
1681613 | 3.NP | N5.1681613 | N | 3.NP | RPO-N3.11
1697805 | 5.NP | N5.1697805 | N1 | 5.NP | RPO-N0.01
1697866 | 5.NP | N5.1697866 | N1 | 5.NP | RPO-N0.02
1697867 | 5.NP | N5.1697867 | N1 | 5.NP | RPO-N0.02
1699410 | 5.NP | N5.1699410 | N1 | 5.NP | RPO-N5.11
1699411 | 5.NP | N5.1699411 | N1 | 5.NP | RPO-N5.11
1710012 | 1.NP | N5.1710012 | N1 | 1.NP | RPO-N1.11
1710566 | 1.S mezipatro | N5.1710566 | N1 | 1.S mezipatro | RPO-N0.11
1716654 | 1.S | N5.1716654 | N1 | 1.S | RPO-N0.02
1900134 | 2.NP | N5.1900134 | N2 | 2.NP | RPO-N2.11
1902976 | 3.NP | N5.1902976 | N | 3.NP | RPO-N3.11
1904497 | 4.NP | N5.1904497 | N | 4.NP | RPO-N4.11
1941757 | 1.S | N5.1941757 | N1 | 1.S | RPO-N0.04
1944904 | 1.S | N5.1944904 | N16 | 1.S | RPO-N0.04
1944954 | 1.S | N5.1944954 | N17 | 1.S | RPO-N0.04
1945307 | 1.S | N5.1945307 | N18 | 1.S | RPO-N0.04
1948917 | 1.S | N5.1948917 | N27 | 1.S | RPO-N0.03
1962600 | 4.NP mezipatro | N5.1962600 | N | 4.NP mezipatro | RPO-N4.01
1962884 | 4.NP | N5.1962884 | N | 4.NP | RPO-N4.11
2179954 | 1.S | N5.2179954 | C | 1.S | RPO-N0.03
2186268 | 1.NP mezipatro | N5.2186268 | N3 | 1.NP mezipatro | RPO-N1.01
2186338 | 2.NP mezipatro | N5.2186338 | N4 | 2.NP mezipatro | RPO-N2.01
2387059 | 1.S mezipatro | N5.2387059 | N1 | 1.S mezipatro | RPO-N0.11

# IfcLightFixture: SIL-Detektor_CO:SIL-Detektor_CO (30)
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Detektor_CO; ElementProjectSpecificDescription: Pohybový detektor
Name (SIL-Detektor_CO:SIL-Detektor_CO:...) | In | ElementProjectSpecificIdentifier
2067466 | 1.S | Detektor CO
2067811 | 1.S | Detektor CO
2067826 | 1.S | Detektor CO
2201924 | 1.NP | Detektor CO
2201936 | 2.NP | Detektor CO
2201946 | 3.NP | Detektor CO
2201957 | 4.NP | Detektor CO
2201967 | 1.S mezipatro | Detektor CO
2202448 | 1.NP | Detektor CO
2202459 | 1.NP | Detektor CO
2203495 | 2.NP | Detektor CO
2203508 | 2.NP | Detektor CO
2205153 | 3.NP | Detektor CO
2205160 | 3.NP | Detektor CO
2206378 | 4.NP | Detektor CO
2206389 | 4.NP | Detektor CO
2207110 | 4.NP mezipatro | Detektor CO
2207119 | 3.NP mezipatro | Detektor CO
2207161 | 2.NP mezipatro | Detektor CO
2207169 | 1.NP mezipatro | Detektor CO
2207604 | 1.NP mezipatro | Detektor CO
2207611 | 1.NP mezipatro | Detektor CO
2209101 | 2.NP mezipatro | Detektor CO
2209110 | 2.NP mezipatro | Detektor CO
2210742 | 3.NP mezipatro | Detektor CO
2210751 | 3.NP mezipatro | Detektor CO
2212894 | 4.NP mezipatro | Detektor CO
2212904 | 4.NP mezipatro | Detektor CO
2252569 | 1.S mezipatro | A15
2252578 | 1.S mezipatro | A16

# IfcLightFixture: SIL-Čidlo pohybu_konektor:SIL-Čidlo pohybu_konektor (207)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: SIL-Čidlo pohybu_konektor; ElementProjectSpecificDescription: Pohybový detektor; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: vypínač, spínač, čidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: QAC
Pset_DistributionSystemCommon - Reference: R-RS
Name (SIL-Čidlo pohybu_konektor:SIL-Čidlo pohybu_konektor:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
1611229 | 1.S | PIR.1611229 | PIR | 1.S | R-RS-LM0.10
1612096 | 1.S | PIR.1612096 | PIR | 1.S | R-RS-LM0.10
1612111 | 1.S | PIR.1612111 | PIR | 1.S | R-RS-LM0.11
1612119 | 1.S | PIR.1612119 | PIR | 1.S | R-RS-LM0.11
1612135 | 1.S | PIR.1612135 | PIR | 1.S | R-RS-LM0.11
1612149 | 1.S | PIR.1612149 | PIR | 1.S | R-RS-LM0.11
1612177 | 1.S | PIR.1612177 | PIR | 1.S | R-RS-LM0.10
1612191 | 1.S | PIR.1612191 | PIR | 1.S | R-RS-LM0.07
1612201 | 1.S | PIR.1612201 | PIR | 1.S | R-RS-LM1.02
1612225 | 1.S | PIR.1612225 | PIR | 1.S | R-RS-LM0.10
1612281 | 1.S | PIR.1612281 | PIR | 1.S | R-RS-LM0.11
1612292 | 1.S | PIR.1612292 | PIR | 1.S | R-RS-LM1.01
1612308 | 1.S | PIR.1612308 | PIR | 1.S | R-RS-LM0.11
1612324 | 1.S | PIR.1612324 | PIR | 1.S | R-RS-LM0.10
1617693 | 1.NP | PIR.1617693 | PIR | 1.NP | R-RS-LM1.13
1627893 | 5.NP | PIR.1627893 | PIR | 5.NP | R-RS-LM1.02
1627916 | 5.NP | PIR.1627916 | PIR | 5.NP | R-RS-LM1.01
1630006 | 2.NP | PIR.1630006 | PIR | 2.NP | R-RS-LM2.13
1630048 | 4.NP | PIR.1630048 | PIR | 4.NP | R-RS-LM4.13
1630731 | 4.NP | PIR.1630731 | PIR | 4.NP | R-RS-LM4.14
1630748 | 2.NP | PIR.1630748 | PIR | 2.NP | R-RS-LM2.14
1630762 | 1.NP | PIR.1630762 | PIR | 1.NP | R-RS-LM1.14
1630778 | 1.S | PIR.1630778 | PIR | 1.S | R-RS-LM0.10
1631663 | 2.NP | PIR.1631663 | PIR | 2.NP | R-RS-LM2.13
1631696 | 2.NP | PIR.1631696 | PIR | 2.NP | R-RS-LM2.13
1631710 | 2.NP | PIR.1631710 | PIR | 2.NP | R-RS-LM2.14
1631724 | 2.NP | PIR.1631724 | PIR | 2.NP | R-RS-LM2.14
1631795 | 2.NP | PIR.1631795 | PIR | 2.NP | R-RS-LM2.14
1631863 | 2.NP | PIR.1631863 | PIR | 2.NP | R-RS-LM2.14
1631873 | 2.NP | PIR.1631873 | PIR | 2.NP | R-RS-LM2.14
1631881 | 2.NP | PIR.1631881 | PIR | 2.NP | R-RS-LM2.14
1631893 | 2.NP | PIR.1631893 | PIR | 2.NP | R-RS-LM2.13
1631905 | 2.NP | PIR.1631905 | PIR | 2.NP | R-RS-LM2.13
1631915 | 2.NP | PIR.1631915 | PIR | 2.NP | R-RS-LM2.14
1631927 | 2.NP | PIR.1631927 | PIR | 2.NP | R-RS-LM2.13
1631939 | 2.NP | PIR.1631939 | PIR | 2.NP | R-RS-LM2.13
1632005 | 2.NP | PIR.1632005 | PIR | 2.NP | R-RS-LM2.13
1632059 | 2.NP | PIR.1632059 | PIR | 2.NP | R-RS-LM1.02
1632134 | 3.NP | PIR.1632134 | PIR | 3.NP | R-RS-LM3.13
1632192 | 3.NP | PIR.1632192 | PIR | 3.NP | R-RS-LM3.13
1632204 | 3.NP | PIR.1632204 | PIR | 3.NP | R-RS-LM3.13
1632218 | 3.NP | PIR.1632218 | PIR | 3.NP | R-RS-LM3.14
1632236 | 3.NP | PIR.1632236 | PIR | 3.NP | R-RS-LM3.14
1632341 | 3.NP | PIR.1632341 | PIR | 3.NP | R-RS-LM3.14
1632406 | 3.NP | PIR.1632406 | PIR | 3.NP | R-RS-LM3.14
1632414 | 3.NP | PIR.1632414 | PIR | 3.NP | R-RS-LM3.14
1632422 | 3.NP | PIR.1632422 | PIR | 3.NP | R-RS-LM3.14
1632434 | 3.NP | PIR.1632434 | PIR | 3.NP | R-RS-LM3.13
1632446 | 3.NP | PIR.1632446 | PIR | 3.NP | R-RS-LM3.14
1632458 | 3.NP | PIR.1632458 | PIR | 3.NP | R-RS-LM3.13
1632466 | 3.NP | PIR.1632466 | PIR | 3.NP | R-RS-LM3.13
1632476 | 3.NP | PIR.1632476 | PIR | 3.NP | R-RS-LM3.13
1632492 | 3.NP | PIR.1632492 | PIR | 3.NP | R-RS-LM3.13
1632502 | 3.NP | PIR.1632502 | PIR | 3.NP | R-RS-LM1.01
1632520 | 3.NP | PIR.1632520 | PIR | 3.NP | R-RS-LM1.02
1632721 | 4.NP | PIR.1632721 | PIR | 4.NP | R-RS-LM4.13
1632734 | 4.NP | PIR.1632734 | PIR | 4.NP | R-RS-LM4.13
1632746 | 4.NP | PIR.1632746 | PIR | 4.NP | R-RS-LM4.14
1632764 | 4.NP | PIR.1632764 | PIR | 4.NP | R-RS-LM4.14
1632774 | 4.NP | PIR.1632774 | PIR | 4.NP | R-RS-LM4.14
1632790 | 4.NP | PIR.1632790 | PIR | 4.NP | R-RS-LM4.14
1632798 | 4.NP | PIR.1632798 | PIR | 4.NP | R-RS-LM4.14
1632808 | 4.NP | PIR.1632808 | PIR | 4.NP | R-RS-LM1.02
1632840 | 4.NP | PIR.1632840 | PIR | 4.NP | R-RS-LM4.14
1632848 | 4.NP | PIR.1632848 | PIR | 4.NP | R-RS-LM4.13
1632858 | 4.NP | PIR.1632858 | PIR | 4.NP | R-RS-LM4.14
1632866 | 4.NP | PIR.1632866 | PIR | 4.NP | R-RS-LM4.13
1632878 | 4.NP | PIR.1632878 | PIR | 4.NP | R-RS-LM4.13
1632908 | 4.NP | PIR.1632908 | PIR | 4.NP | R-RS-LM4.13
1632918 | 4.NP | PIR.1632918 | PIR | 4.NP | R-RS-LM4.13
1632930 | 4.NP | PIR.1632930 | PIR | 4.NP | R-RS-LM1.01
1633158 | 4.NP mezipatro | PIR.1633158 | PIR | 4.NP mezipatro | R-RS-LM4.03
1633224 | 3.NP mezipatro | PIR.1633224 | PIR | 3.NP mezipatro | R-RS-LM3.03
1633263 | 1.NP mezipatro | PIR.1633263 | PIR | 1.NP mezipatro | R-RS-LM1.06
1633280 | 1.S mezipatro | PIR.1633280 | PIR | 1.S mezipatro | R-RS-LM0.13
1633298 | 5.NP | PIR.1633298 | PIR | 5.NP | R-RS-LM5.15
1633971 | 1.NP mezipatro | PIR.1633971 | PIR | 1.NP mezipatro | R-RS-LM1.06
1633982 | 1.NP mezipatro | PIR.1633982 | PIR | 1.NP mezipatro | R-RS-LM1.06
1634000 | 1.NP mezipatro | PIR.1634000 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634014 | 1.NP mezipatro | PIR.1634014 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634030 | 1.NP mezipatro | PIR.1634030 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634038 | 1.NP mezipatro | PIR.1634038 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634050 | 1.NP mezipatro | PIR.1634050 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634062 | 1.NP mezipatro | PIR.1634062 | PIR | 1.NP mezipatro | R-RS-LM1.06
1634080 | 1.NP mezipatro | PIR.1634080 | PIR | 1.NP mezipatro | R-RS-LM1.06
1634094 | 1.NP mezipatro | PIR.1634094 | PIR | 1.NP mezipatro | R-RS-LM1.06
1634102 | 1.NP mezipatro | PIR.1634102 | PIR | 1.NP mezipatro | R-RS-LM1.01
1634112 | 1.NP mezipatro | PIR.1634112 | PIR | 1.NP mezipatro | R-RS-LM1.06
1634193 | 1.NP mezipatro | PIR.1634193 | PIR | 1.NP mezipatro | R-RS-LM1.06
1634257 | 1.NP mezipatro | PIR.1634257 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634271 | 1.NP mezipatro | PIR.1634271 | PIR | 1.NP mezipatro | R-RS-LM1.05
1634439 | 2.NP mezipatro | PIR.1634439 | PIR | 2.NP mezipatro | R-RS-LM1.01
1634457 | 2.NP mezipatro | PIR.1634457 | PIR | 2.NP mezipatro | R-RS-LM2.03
1634465 | 2.NP mezipatro | PIR.1634465 | PIR | 2.NP mezipatro | R-RS-LM2.03
1634482 | 2.NP mezipatro | PIR.1634482 | PIR | 2.NP mezipatro | R-RS-LM2.03
1634496 | 2.NP mezipatro | PIR.1634496 | PIR | 2.NP mezipatro | R-RS-LM2.03
1634504 | 2.NP mezipatro | PIR.1634504 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634514 | 2.NP mezipatro | PIR.1634514 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634526 | 2.NP mezipatro | PIR.1634526 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634534 | 2.NP mezipatro | PIR.1634534 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634548 | 2.NP mezipatro | PIR.1634548 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634564 | 2.NP mezipatro | PIR.1634564 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634578 | 2.NP mezipatro | PIR.1634578 | PIR | 2.NP mezipatro | R-RS-LM2.03
1634590 | 2.NP mezipatro | PIR.1634590 | PIR | 2.NP mezipatro | R-RS-LM2.03
1634606 | 2.NP mezipatro | PIR.1634606 | PIR | 2.NP mezipatro | R-RS-LM2.04
1634614 | 2.NP mezipatro | PIR.1634614 | PIR | 2.NP mezipatro | R-RS-LM1.02
1634733 | 3.NP mezipatro | PIR.1634733 | PIR | 3.NP mezipatro | R-RS-LM3.03
1634742 | 3.NP mezipatro | PIR.1634742 | PIR | 3.NP mezipatro | R-RS-LM1.01
1634756 | 3.NP mezipatro | PIR.1634756 | PIR | 3.NP mezipatro | R-RS-LM3.03
1634794 | 3.NP mezipatro | PIR.1634794 | PIR | 3.NP mezipatro | R-RS-LM3.03
1634808 | 3.NP mezipatro | PIR.1634808 | PIR | 3.NP mezipatro | R-RS-LM3.03
1634820 | 3.NP mezipatro | PIR.1634820 | PIR | 3.NP mezipatro | R-RS-LM3.03
1634828 | 3.NP mezipatro | PIR.1634828 | PIR | 3.NP mezipatro | R-RS-LM3.04
1634838 | 3.NP mezipatro | PIR.1634838 | PIR | 3.NP mezipatro | R-RS-LM3.04
1634850 | 3.NP mezipatro | PIR.1634850 | PIR | 3.NP mezipatro | R-RS-LM3.04
1634858 | 3.NP mezipatro | PIR.1634858 | PIR | 3.NP mezipatro | R-RS-LM3.04
1634868 | 3.NP mezipatro | PIR.1634868 | PIR | 3.NP mezipatro | R-RS-LM3.04
1634876 | 3.NP mezipatro | PIR.1634876 | PIR | 3.NP mezipatro | R-RS-LM3.04
1634890 | 3.NP mezipatro | PIR.1634890 | PIR | 3.NP mezipatro | R-RS-LM3.03
1634916 | 3.NP mezipatro | PIR.1634916 | PIR | 3.NP mezipatro | R-RS-LM1.02
1634930 | 3.NP mezipatro | PIR.1634930 | PIR | 3.NP mezipatro | R-RS-LM3.03
1635050 | 4.NP mezipatro | PIR.1635050 | PIR | 4.NP mezipatro | R-RS-LM4.03
1635067 | 4.NP mezipatro | PIR.1635067 | PIR | 4.NP mezipatro | R-RS-LM4.03
1635079 | 4.NP mezipatro | PIR.1635079 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635089 | 4.NP mezipatro | PIR.1635089 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635099 | 4.NP mezipatro | PIR.1635099 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635107 | 4.NP mezipatro | PIR.1635107 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635119 | 4.NP mezipatro | PIR.1635119 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635131 | 4.NP mezipatro | PIR.1635131 | PIR | 4.NP mezipatro | R-RS-LM1.02
1635141 | 4.NP mezipatro | PIR.1635141 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635155 | 4.NP mezipatro | PIR.1635155 | PIR | 4.NP mezipatro | R-RS-LM4.04
1635163 | 4.NP mezipatro | PIR.1635163 | PIR | 4.NP mezipatro | R-RS-LM4.03
1635177 | 4.NP mezipatro | PIR.1635177 | PIR | 4.NP mezipatro | R-RS-LM4.03
1635185 | 4.NP mezipatro | PIR.1635185 | PIR | 4.NP mezipatro | R-RS-LM4.03
1635209 | 4.NP mezipatro | PIR.1635209 | PIR | 4.NP mezipatro | R-RS-LM1.01
1635246 | 4.NP mezipatro | PIR.1635246 | PIR | 4.NP mezipatro | R-RS-LM4.03
1639527 | 1.S mezipatro | PIR.1639527 | PIR | 1.S mezipatro | R-RS-LM0.13
1639544 | 1.S mezipatro | PIR.1639544 | PIR | 1.S mezipatro | R-RS-LM0.13
1639556 | 1.S mezipatro | PIR.1639556 | PIR | 1.S mezipatro | R-RS-LM0.12
1639566 | 1.S mezipatro | PIR.1639566 | PIR | 1.S mezipatro | R-RS-LM0.12
1639578 | 1.S mezipatro | PIR.1639578 | PIR | 1.S mezipatro | R-RS-LM0.12
1639586 | 1.S mezipatro | PIR.1639586 | PIR | 1.S mezipatro | R-RS-LM0.12
1639606 | 1.S mezipatro | PIR.1639606 | PIR | 1.S mezipatro | R-RS-LM0.12
1639620 | 1.S mezipatro | PIR.1639620 | PIR | 1.S mezipatro | R-RS-LM0.13
1639634 | 1.S mezipatro | PIR.1639634 | PIR | 1.S mezipatro | R-RS-LM0.13
1639650 | 1.S mezipatro | PIR.1639650 | PIR | 1.S mezipatro | R-RS-LM0.13
1639662 | 1.S mezipatro | PIR.1639662 | PIR | 1.S mezipatro | R-RS-LM1.01
1639782 | 1.NP | PIR.1639782 | PIR | 1.NP | R-RS-LM1.13
1639846 | 1.NP | PIR.1639846 | PIR | 1.NP | R-RS-LM1.14
1639856 | 1.NP | PIR.1639856 | PIR | 1.NP | R-RS-LM1.14
1639864 | 1.NP | PIR.1639864 | PIR | 1.NP | R-RS-LM1.14
1639874 | 1.NP | PIR.1639874 | PIR | 1.NP | R-RS-LM1.14
1639884 | 1.NP | PIR.1639884 | PIR | 1.NP | R-RS-LM1.14
1639894 | 1.NP | PIR.1639894 | PIR | 1.NP | R-RS-LM1.14
1639904 | 1.NP | PIR.1639904 | PIR | 1.NP | R-RS-LM1.02
1639920 | 1.NP | PIR.1639920 | PIR | 1.NP | R-RS-LM1.14
1639939 | 1.NP | PIR.1639939 | PIR | 1.NP | R-RS-LM1.13
1639947 | 1.NP | PIR.1639947 | PIR | 1.NP | R-RS-LM1.14
1639959 | 1.NP | PIR.1639959 | PIR | 1.NP | R-RS-LM1.13
1639967 | 1.NP | PIR.1639967 | PIR | 1.NP | R-RS-LM1.13
1639981 | 1.NP | PIR.1639981 | PIR | 1.NP | R-RS-LM1.13
1639997 | 1.NP | PIR.1639997 | PIR | 1.NP | R-RS-LM1.13
1640007 | 1.NP | PIR.1640007 | PIR | 1.NP | R-RS-LM1.01
1658646 | 1.S mezipatro | PIR.1658646 | PIR | 1.S mezipatro | R-RS-LM1.02
1661280 | 1.S mezipatro | PIR.1661280 | PIR | 1.S mezipatro | R-RS-LM0.13
1666376 | 2.NP | PIR.1666376 | PIR | 2.NP | R-RS-LM2.14
1666492 | 1.NP mezipatro | PIR.1666492 | PIR | 1.NP mezipatro | R-RS-LM1.06
1669432 | 2.NP | PIR.1669432 | PIR | 2.NP | R-RS-LM1.01
1670276 | 1.NP mezipatro | PIR.1670276 | PIR | 1.NP mezipatro | R-RS-LM1.02
1670714 | 2.NP mezipatro | PIR.1670714 | PIR | 2.NP mezipatro | R-RS-LM2.03
1678468 | 3.NP mezipatro | PIR.1678468 | PIR | 3.NP mezipatro | R-RS-LM3.03
1679490 | 3.NP | PIR.1679490 | PIR | 3.NP | R-RS-LM3.14
1685267 | 5.NP | PIR.1685267 | PIR | 5.NP | R-RS-LM5.14
1685557 | 5.NP | PIR.1685557 | PIR | 5.NP | R-RS-LM5.13
1697694 | 5.NP | PIR.1697694 | PIR | 5.NP | R-RS-LM1.01
1699259 | 5.NP | PIR.1699259 | PIR | 5.NP | R-RS-LM5.13
1699261 | 5.NP | PIR.1699261 | PIR | 5.NP | R-RS-LM5.03
1699291 | 5.NP | PIR.1699291 | PIR | 5.NP | R-RS-LM5.13
1699334 | 5.NP | PIR.1699334 | PIR | 5.NP | R-RS-LM5.04
1699336 | 5.NP | PIR.1699336 | PIR | 5.NP | R-RS-LM5.04
1808219 | 1.S | PIR.1808219 | PIR | 1.S | R-RS-LM0.11
1949322 | 1.S | PIR.1949322 | PIR | 1.S | R-RS-VZT.01
1949479 | 1.S | PIR.1949479 | PIR | 1.S | R-RS-LM0.08
1961293 | 5.NP | PIR.1961293 | PIR | 5.NP | R-RS-LM1.02
1963344 | 3.NP mezipatro | PIR.1963344 | PIR | 3.NP mezipatro | R-RS-LM3.04
1975681 | 2.NP mezipatro | PIR.1975681 | PIR | 2.NP mezipatro | R-RS-LM2.03
1976972 | 2.NP mezipatro | PIR.1976972 | PIR | 2.NP mezipatro | R-RS-LM2.03
2036098 | 1.S | PIR.2036098 | PIR | 1.S | R-RS-LM0.10
2068536 | 1.S mezipatro | PIR.2068536 | PIR | 1.S mezipatro | R-RS-LM0.13
2068555 | 1.S mezipatro | PIR.2068555 | PIR | 1.S mezipatro | R-RS-LM0.13
2068569 | 1.S mezipatro | PIR.2068569 | PIR | 1.S mezipatro | R-RS-LM0.12
2068579 | 1.S mezipatro | PIR.2068579 | PIR | 1.S mezipatro | R-RS-LM0.12
2140047 | 5.NP | PIR.2140047 | PIR | 5.NP | R-RS-LM5.14
2186974 | 1.S | PIR.2186974 | PIR | 1.S | R-RS-LM0.10
2187288 | 1.NP | PIR.2187288 | PIR | 1.NP | R-RS-LM1.14
2188150 | 3.NP | PIR.2188150 | PIR | 3.NP | R-RS-LM3.14
2188415 | 4.NP | PIR.2188415 | PIR | 4.NP | R-RS-LM4.14
2196896 | 1.S | PIR.2196896 | PIR | 1.S | R-RS-VZT.01
2196932 | 1.S | PIR.2196932 | PIR | 1.S | R-RS-VZT.01
2239111 | 5.NP | PIR.2239111 | PIR | 5.NP | R-RS-LM5.13
2239253 | 5.NP | PIR.2239253 | PIR | 5.NP | R-RS-LM5.15
2367606 | 1.S | PIR.2367606 | A105 | 1.S | R-RS-LM0.11
2374514 | 1.S | PIR.2374514 | A106 | 1.S | R-RS-LM0.11
2413524 | 1.S | PIR.2413524 | PIR | 1.S | R-RS-VZT.01
2413603 | 1.S | PIR.2413603 | PIR | 1.S | R-RS-VZT.01
2413690 | 1.S | PIR.2413690 | PIR | 1.S | R-RS-VZT.01
2415081 | 1.S | PIR.2415081 | PIR | 1.S | R-RS-VZT.01

# IfcLightFixture: Světlo A1:1570x95, přisazené (4)
In: 5.NP
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1570x95, přisazené; ElementProjectSpecificDescription: svítidlo přisazené/zavěšené LED 54W; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
CZ_ElementCommon - ElementProjectSpecificIdentifier: A1; StoreyProjectSpecificIdentifier: 5.NP
Pset_DistributionSystemCommon - Reference: R-RS
Name (Světlo A1:1570x95, přisazené:...) | CZ_ElementCommon, Reference | Pset_JunctionBoxTypeCommon, Reference
1271215 | xxx.1271215 | R-RS-LM5.04
1271269 | xxx.1271269 | R-RS-LM5.13
1274165 | xxx.1274165 | R-RS-LM5.15
1274307 | xxx.1274307 | R-RS-LM5.14

# IfcLightFixture: Světlo A1_vzor:1270x95, přisazené (11)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1270x95, přisazené; ElementProjectSpecificDescription: Svítidlo přisazené LED 43W; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: UAC
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: R-RS
Name (Světlo A1_vzor:1270x95, přisazené:...) | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
2115491 | .2115491 | A2 | R-RS-LM0.04
2115936 | .2115936 | A2 | R-RS-LM0.04
2115944 | .2115944 | A2 | R-RS-LM0.06
2115952 | .2115952 | A2 | R-RS-LM0.06
2115960 | .2115960 | A2 | R-RS-LM0.05
2115970 | .2115970 | A2 | R-RS-LM0.05
2115980 | .2115980 | NNNNNNNNNNNNNNN | R-RS-LM0.03
2115988 | .2115988 | A2 | R-RS-LM0.02
2115996 | .2115996 | A2 | R-RS-LM0.01
2116004 | .2116004 | A2 | R-RS-LM0.01
2116012 | .2116012 | A2 | R-RS-LM0.01

# IfcLightFixture: Světlo A1_vzor:1570x95, přisazené (267)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1570x95, přisazené; ElementProjectSpecificDescription: svítidlo přisazené/zavěšené LED 54W; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
Pset_DistributionSystemCommon - Reference: R-RS
Name (Světlo A1_vzor:1570x95, přisazené:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
2026269 | 1.S | xxx.2026269 | A1 | 1.S | R-RS-LM0.11
2026281 | 1.S | xxx.2026281 | A1 | 1.S | R-RS-LM0.11
2026297 | 1.S | xxx.2026297 | A1 | 1.S | R-RS-LM0.11
2026311 | 1.S | xxx.2026311 | A1 | 1.S | R-RS-LM0.10
2026323 | 1.S | xxx.2026323 | A1 | 1.S | R-RS-LM0.10
2026335 | 1.S | xxx.2026335 | A1 | 1.S | R-RS-LM0.10
2026349 | 1.S | xxx.2026349 | A1 | 1.S | R-RS-LM0.10
2026363 | 1.S | xxx.2026363 | A1 | 1.S | R-RS-LM0.10
2026383 | 1.S | xxx.2026383 | A1 | 1.S | R-RS-LM0.10
2026395 | 1.S | xxx.2026395 | A1 | 1.S | R-RS-LM0.10
2026407 | 1.S | xxx.2026407 | A1 | 1.S | R-RS-LM0.11
2026417 | 1.S | xxx.2026417 | A1 | 1.S | R-RS-LM0.11
2026433 | 1.S | xxx.2026433 | A1 | 1.S | R-RS-LM0.11
2026451 | 1.S | xxx.2026451 | A1 | 1.S | R-RS-LM0.11
2026471 | 1.S | xxx.2026471 | A1 | 1.S | R-RS-LM0.11
2026481 | 1.S | xxx.2026481 | A1 | 1.S | R-RS-LM0.11
2026493 | 1.S | xxx.2026493 | A1 | 1.S | R-RS-LM0.11
2026505 | 1.S | xxx.2026505 | A1 | 1.S | R-RS-LM0.11
2026644 | 1.S mezipatro | xxx.2026644 | A1 | 1.S mezipatro | R-RS-LM0.13
2026661 | 1.S mezipatro | xxx.2026661 | A1 | 1.S mezipatro | R-RS-LM0.13
2026673 | 1.S mezipatro | xxx.2026673 | A1 | 1.S mezipatro | R-RS-LM0.13
2026687 | 1.S mezipatro | xxx.2026687 | A1 | 1.S mezipatro | R-RS-LM0.13
2026703 | 1.S mezipatro | xxx.2026703 | A1 | 1.S mezipatro | R-RS-LM0.13
2026717 | 1.S mezipatro | xxx.2026717 | A1 | 1.S mezipatro | R-RS-LM0.12
2026731 | 1.S mezipatro | xxx.2026731 | A1 | 1.S mezipatro | R-RS-LM0.12
2026751 | 1.S mezipatro | xxx.2026751 | A1 | 1.S mezipatro | R-RS-LM0.12
2026767 | 1.S mezipatro | xxx.2026767 | A1 | 1.S mezipatro | R-RS-LM0.12
2026777 | 1.S mezipatro | xxx.2026777 | A1 | 1.S mezipatro | R-RS-LM0.12
2026791 | 1.S mezipatro | xxx.2026791 | A1 | 1.S mezipatro | R-RS-LM0.12
2026809 | 1.S mezipatro | xxx.2026809 | A1 | 1.S mezipatro | R-RS-LM0.12
2026817 | 1.S mezipatro | xxx.2026817 | A1 | 1.S mezipatro | R-RS-LM0.12
2026835 | 1.S mezipatro | xxx.2026835 | A1 | 1.S mezipatro | R-RS-LM0.12
2026849 | 1.S mezipatro | xxx.2026849 | A1 | 1.S mezipatro | R-RS-LM0.13
2026867 | 1.S mezipatro | xxx.2026867 | A1 | 1.S mezipatro | R-RS-LM0.13
2026883 | 1.S mezipatro | xxx.2026883 | A1 | 1.S mezipatro | R-RS-LM0.13
2026899 | 1.S mezipatro | xxx.2026899 | A1 | 1.S mezipatro | R-RS-LM0.13
2026909 | 1.S mezipatro | xxx.2026909 | A1 | 1.S mezipatro | R-RS-LM0.13
2026923 | 1.S mezipatro | xxx.2026923 | A1 | 1.S mezipatro | R-RS-LM0.13
2026937 | 1.S mezipatro | xxx.2026937 | A1 | 1.S mezipatro | R-RS-LM0.13
2026951 | 1.S mezipatro | xxx.2026951 | A1 | 1.S mezipatro | R-RS-LM0.12
2026963 | 1.S mezipatro | xxx.2026963 | A1 | 1.S mezipatro | R-RS-LM0.12
2027029 | 1.S mezipatro | xxx.2027029 | A1 | 1.S mezipatro | R-RS-LM0.13
2027053 | 1.S mezipatro | xxx.2027053 | A1 | 1.S mezipatro | R-RS-LM0.12
2027653 | 1.S mezipatro | xxx.2027653 | A1 | 1.S mezipatro | R-RS-LM0.13
2027931 | 1.S | xxx.2027931 | A1 | 1.S | R-RS-LM0.11
2027949 | 1.S | xxx.2027949 | A1 | 1.S | R-RS-LM0.11
2027971 | 1.S | xxx.2027971 | A1 | 1.S | R-RS-LM0.11
2027979 | 1.S | xxx.2027979 | A1 | 1.S | R-RS-LM0.10
2027991 | 1.S | xxx.2027991 | A1 | 1.S | R-RS-LM0.10
2028017 | 1.S | xxx.2028017 | A1 | 1.S | R-RS-LM0.10
2033344 | 2.NP mezipatro | xxx.2033344 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033358 | 2.NP mezipatro | xxx.2033358 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033374 | 2.NP mezipatro | xxx.2033374 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033388 | 2.NP mezipatro | xxx.2033388 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033398 | 2.NP mezipatro | xxx.2033398 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033412 | 2.NP mezipatro | xxx.2033412 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033430 | 2.NP mezipatro | xxx.2033430 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033442 | 2.NP mezipatro | xxx.2033442 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033456 | 2.NP mezipatro | xxx.2033456 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033476 | 2.NP mezipatro | xxx.2033476 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033490 | 2.NP mezipatro | xxx.2033490 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033502 | 2.NP mezipatro | xxx.2033502 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033518 | 2.NP mezipatro | xxx.2033518 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033532 | 2.NP mezipatro | xxx.2033532 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033548 | 2.NP mezipatro | xxx.2033548 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033566 | 2.NP mezipatro | xxx.2033566 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033580 | 2.NP mezipatro | xxx.2033580 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033592 | 2.NP mezipatro | xxx.2033592 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033606 | 2.NP mezipatro | xxx.2033606 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033618 | 2.NP mezipatro | xxx.2033618 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033632 | 2.NP mezipatro | xxx.2033632 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033646 | 2.NP mezipatro | xxx.2033646 | A1 | 2.NP mezipatro | R-RS-LM2.03
2033658 | 2.NP mezipatro | xxx.2033658 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033670 | 2.NP mezipatro | xxx.2033670 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033692 | 2.NP mezipatro | xxx.2033692 | A1 | 2.NP mezipatro | R-RS-LM2.04
2033710 | 2.NP mezipatro | xxx.2033710 | A1 | 2.NP mezipatro | R-RS-LM2.04
2038677 | 2.NP | xxx.2038677 | A1 | 2.NP | R-RS-LM2.13
2038685 | 2.NP | xxx.2038685 | A1 | 2.NP | R-RS-LM2.13
2038693 | 2.NP | xxx.2038693 | A1 | 2.NP | R-RS-LM2.13
2038705 | 2.NP | xxx.2038705 | A1 | 2.NP | R-RS-LM2.13
2038721 | 2.NP | xxx.2038721 | A1 | 2.NP | R-RS-LM2.13
2038735 | 2.NP | xxx.2038735 | A1 | 2.NP | R-RS-LM2.14
2038747 | 2.NP | xxx.2038747 | A1 | 2.NP | R-RS-LM2.14
2038769 | 2.NP | xxx.2038769 | A1 | 2.NP | R-RS-LM2.14
2038793 | 2.NP | xxx.2038793 | A1 | 2.NP | R-RS-LM2.14
2038805 | 2.NP | xxx.2038805 | A1 | 2.NP | R-RS-LM2.14
2038817 | 2.NP | xxx.2038817 | A1 | 2.NP | R-RS-LM2.14
2038829 | 2.NP | xxx.2038829 | A1 | 2.NP | R-RS-LM2.14
2038841 | 2.NP | xxx.2038841 | A1 | 2.NP | R-RS-LM2.14
2038855 | 2.NP | xxx.2038855 | A1 | 2.NP | R-RS-LM2.14
2038867 | 2.NP | xxx.2038867 | A1 | 2.NP | R-RS-LM2.14
2038885 | 2.NP | xxx.2038885 | A1 | 2.NP | R-RS-LM2.14
2038901 | 2.NP | xxx.2038901 | A1 | 2.NP | R-RS-LM2.13
2038919 | 2.NP | xxx.2038919 | A1 | 2.NP | R-RS-LM2.13
2038929 | 2.NP | xxx.2038929 | A1 | 2.NP | R-RS-LM2.13
2038943 | 2.NP | xxx.2038943 | A1 | 2.NP | R-RS-LM2.13
2038957 | 2.NP | xxx.2038957 | A1 | 2.NP | R-RS-LM2.13
2038971 | 2.NP | xxx.2038971 | A1 | 2.NP | R-RS-LM2.13
2038983 | 2.NP | xxx.2038983 | A1 | 2.NP | R-RS-LM2.13
2038997 | 2.NP | xxx.2038997 | A1 | 2.NP | R-RS-LM2.13
2039019 | 2.NP | xxx.2039019 | A1 | 2.NP | R-RS-LM2.13
2041349 | 3.NP mezipatro | xxx.2041349 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041363 | 3.NP mezipatro | xxx.2041363 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041381 | 3.NP mezipatro | xxx.2041381 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041397 | 3.NP mezipatro | xxx.2041397 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041415 | 3.NP mezipatro | xxx.2041415 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041441 | 3.NP mezipatro | xxx.2041441 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041453 | 3.NP mezipatro | xxx.2041453 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041465 | 3.NP mezipatro | xxx.2041465 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041479 | 3.NP mezipatro | xxx.2041479 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041491 | 3.NP mezipatro | xxx.2041491 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041501 | 3.NP mezipatro | xxx.2041501 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041511 | 3.NP mezipatro | xxx.2041511 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041527 | 3.NP mezipatro | xxx.2041527 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041545 | 3.NP mezipatro | xxx.2041545 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041561 | 3.NP mezipatro | xxx.2041561 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041577 | 3.NP mezipatro | xxx.2041577 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041591 | 3.NP mezipatro | xxx.2041591 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041607 | 3.NP mezipatro | xxx.2041607 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041625 | 3.NP mezipatro | xxx.2041625 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041645 | 3.NP mezipatro | xxx.2041645 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041659 | 3.NP mezipatro | xxx.2041659 | A1 | 3.NP mezipatro | R-RS-LM3.03
2041669 | 3.NP mezipatro | xxx.2041669 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041679 | 3.NP mezipatro | xxx.2041679 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041693 | 3.NP mezipatro | xxx.2041693 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041707 | 3.NP mezipatro | xxx.2041707 | A1 | 3.NP mezipatro | R-RS-LM3.04
2041776 | 3.NP | xxx.2041776 | A1 | 3.NP | R-RS-LM3.13
2041791 | 3.NP | xxx.2041791 | A1 | 3.NP | R-RS-LM3.13
2041813 | 3.NP | xxx.2041813 | A1 | 3.NP | R-RS-LM3.13
2041823 | 3.NP | xxx.2041823 | A1 | 3.NP | R-RS-LM3.13
2041837 | 3.NP | xxx.2041837 | A1 | 3.NP | R-RS-LM3.14
2041855 | 3.NP | xxx.2041855 | A1 | 3.NP | R-RS-LM3.14
2041869 | 3.NP | xxx.2041869 | A1 | 3.NP | R-RS-LM3.14
2041887 | 3.NP | xxx.2041887 | A1 | 3.NP | R-RS-LM3.14
2041899 | 3.NP | xxx.2041899 | A1 | 3.NP | R-RS-LM3.14
2041907 | 3.NP | xxx.2041907 | A1 | 3.NP | R-RS-LM3.14
2041917 | 3.NP | xxx.2041917 | A1 | 3.NP | R-RS-LM3.14
2041935 | 3.NP | xxx.2041935 | A1 | 3.NP | R-RS-LM3.14
2041947 | 3.NP | xxx.2041947 | A1 | 3.NP | R-RS-LM3.14
2041965 | 3.NP | xxx.2041965 | A1 | 3.NP | R-RS-LM3.13
2041979 | 3.NP | xxx.2041979 | A1 | 3.NP | R-RS-LM3.13
2041989 | 3.NP | xxx.2041989 | A1 | 3.NP | R-RS-LM3.13
2042001 | 3.NP | xxx.2042001 | A1 | 3.NP | R-RS-LM3.13
2042021 | 3.NP | xxx.2042021 | A1 | 3.NP | R-RS-LM3.13
2042039 | 3.NP | xxx.2042039 | A1 | 3.NP | R-RS-LM3.13
2042049 | 3.NP | xxx.2042049 | A1 | 3.NP | R-RS-LM3.13
2042061 | 3.NP | xxx.2042061 | A1 | 3.NP | R-RS-LM3.13
2042077 | 3.NP | xxx.2042077 | A1 | 3.NP | R-RS-LM3.13
2042095 | 3.NP | xxx.2042095 | A1 | 3.NP | R-RS-LM3.13
2042661 | 3.NP | xxx.2042661 | A1 | 3.NP | R-RS-LM3.13
2042710 | 3.NP | xxx.2042710 | A1 | 3.NP | R-RS-LM3.14
2042773 | 4.NP mezipatro | xxx.2042773 | A1 | 4.NP mezipatro | R-RS-LM4.03
2042783 | 4.NP mezipatro | xxx.2042783 | A1 | 4.NP mezipatro | R-RS-LM4.03
2042796 | 4.NP mezipatro | xxx.2042796 | A1 | 4.NP mezipatro | R-RS-LM4.03
2042816 | 4.NP mezipatro | xxx.2042816 | A1 | 4.NP mezipatro | R-RS-LM4.03
2042830 | 4.NP mezipatro | xxx.2042830 | A1 | 4.NP mezipatro | R-RS-LM4.03
2042850 | 4.NP mezipatro | xxx.2042850 | A1 | 4.NP mezipatro | R-RS-LM4.04
2042866 | 4.NP mezipatro | xxx.2042866 | A1 | 4.NP mezipatro | R-RS-LM4.04
2042882 | 4.NP mezipatro | xxx.2042882 | A1 | 4.NP mezipatro | R-RS-LM4.04
2042894 | 4.NP mezipatro | xxx.2042894 | A1 | 4.NP mezipatro | R-RS-LM4.04
2043018 | 4.NP mezipatro | xxx.2043018 | A1 | 4.NP mezipatro | R-RS-LM4.03
2043038 | 4.NP mezipatro | xxx.2043038 | A1 | 4.NP mezipatro | R-RS-LM4.03
2043054 | 4.NP mezipatro | xxx.2043054 | A1 | 4.NP mezipatro | R-RS-LM4.03
2043070 | 4.NP mezipatro | xxx.2043070 | A1 | 4.NP mezipatro | R-RS-LM4.03
2043092 | 4.NP mezipatro | xxx.2043092 | A1 | 4.NP mezipatro | R-RS-LM4.04
2043142 | 4.NP mezipatro | xxx.2043142 | A1 | 4.NP mezipatro | R-RS-LM4.04
2043172 | 4.NP mezipatro | xxx.2043172 | A1 | 4.NP mezipatro | R-RS-LM4.04
2043196 | 4.NP mezipatro | xxx.2043196 | A1 | 4.NP mezipatro | R-RS-LM4.04
2043251 | 4.NP | xxx.2043251 | A1 | 4.NP | R-RS-LM4.13
2043263 | 4.NP | xxx.2043263 | A1 | 4.NP | R-RS-LM4.13
2043280 | 4.NP | xxx.2043280 | A1 | 4.NP | R-RS-LM4.13
2043298 | 4.NP | xxx.2043298 | A1 | 4.NP | R-RS-LM4.13
2043316 | 4.NP | xxx.2043316 | A1 | 4.NP | R-RS-LM4.14
2043330 | 4.NP | xxx.2043330 | A1 | 4.NP | R-RS-LM4.14
2043350 | 4.NP | xxx.2043350 | A1 | 4.NP | R-RS-LM4.14
2043366 | 4.NP | xxx.2043366 | A1 | 4.NP | R-RS-LM4.14
2043380 | 4.NP | xxx.2043380 | A1 | 4.NP | R-RS-LM4.14
2043390 | 4.NP | xxx.2043390 | A1 | 4.NP | R-RS-LM4.14
2043398 | 4.NP | xxx.2043398 | A1 | 4.NP | R-RS-LM4.14
2043414 | 4.NP | xxx.2043414 | A1 | 4.NP | R-RS-LM4.14
2043424 | 4.NP | xxx.2043424 | A1 | 4.NP | R-RS-LM4.14
2043438 | 4.NP | xxx.2043438 | A1 | 4.NP | R-RS-LM4.13
2043448 | 4.NP | xxx.2043448 | A1 | 4.NP | R-RS-LM4.13
2043458 | 4.NP | xxx.2043458 | A1 | 4.NP | R-RS-LM4.13
2043472 | 4.NP | xxx.2043472 | A1 | 4.NP | R-RS-LM4.13
2043482 | 4.NP | xxx.2043482 | A1 | 4.NP | R-RS-LM4.13
2043498 | 4.NP | xxx.2043498 | A1 | 4.NP | R-RS-LM4.13
2043516 | 4.NP | xxx.2043516 | A1 | 4.NP | R-RS-LM4.13
2043524 | 4.NP | xxx.2043524 | A1 | 4.NP | R-RS-LM4.13
2043532 | 4.NP | xxx.2043532 | A1 | 4.NP | R-RS-LM4.13
2043546 | 4.NP | xxx.2043546 | A1 | 4.NP | R-RS-LM4.13
2043560 | 4.NP | xxx.2043560 | A1 | 4.NP | R-RS-LM4.13
2043942 | 5.NP | xxx.2043942 | A1 | 5.NP | R-RS-LM5.14
2043960 | 5.NP | xxx.2043960 | A1 | 5.NP | R-RS-LM5.14
2043980 | 5.NP | xxx.2043980 | A1 | 5.NP | R-RS-LM5.15
2043998 | 5.NP | xxx.2043998 | A1 | 5.NP | R-RS-LM5.04
2044006 | 5.NP | xxx.2044006 | A1 | 5.NP | R-RS-LM5.15
2053945 | 3.NP mezipatro | xxx.2053945 | A1 | 3.NP mezipatro | R-RS-LM3.03
2054025 | 4.NP | xxx.2054025 | A1 | 4.NP | R-RS-LM4.14
2054043 | 4.NP | xxx.2054043 | A1 | 4.NP | R-RS-LM4.14
2054317 | 5.NP | xxx.2054317 | A1 | 5.NP | R-RS-LM5.03
2054333 | 5.NP | xxx.2054333 | A1 | 5.NP | R-RS-LM5.03
2054345 | 5.NP | xxx.2054345 | A1 | 5.NP | R-RS-LM5.13
2054359 | 5.NP | xxx.2054359 | A1 | 5.NP | R-RS-LM5.04
2054367 | 5.NP | xxx.2054367 | A1 | 5.NP | R-RS-LM5.04
2054395 | 5.NP | xxx.2054395 | A1 | 5.NP | R-RS-LM5.13
2054405 | 5.NP | xxx.2054405 | A1 | 5.NP | R-RS-LM5.13
2054413 | 5.NP | xxx.2054413 | A1 | 5.NP | R-RS-LM5.13
2054421 | 5.NP | xxx.2054421 | A1 | 5.NP | R-RS-LM5.14
2094207 | 1.NP | xxx.2094207 | A1 | 1.NP | R-RS-LM1.14
2094262 | 1.NP mezipatro | xxx.2094262 | A1 | 1.NP mezipatro | R-RS-LM1.05
2094571 | 1.NP | xxx.2094571 | A1 | 1.NP | R-RS-LM1.14
2094585 | 1.NP | xxx.2094585 | A1 | 1.NP | R-RS-LM1.14
2094601 | 1.NP | xxx.2094601 | A1 | 1.NP | R-RS-LM1.14
2094615 | 1.NP | xxx.2094615 | A1 | 1.NP | R-RS-LM1.14
2094627 | 1.NP | xxx.2094627 | A1 | 1.NP | R-RS-LM1.13
2094635 | 1.NP | xxx.2094635 | A1 | 1.NP | R-RS-LM1.13
2094651 | 1.NP | xxx.2094651 | A1 | 1.NP | R-RS-LM1.13
2094665 | 1.NP | xxx.2094665 | A1 | 1.NP | R-RS-LM1.13
2094673 | 1.NP | xxx.2094673 | A1 | 1.NP | R-RS-LM1.13
2094685 | 1.NP | xxx.2094685 | A1 | 1.NP | R-RS-LM1.13
2094695 | 1.NP | xxx.2094695 | A1 | 1.NP | R-RS-LM1.13
2094707 | 1.NP | xxx.2094707 | A1 | 1.NP | R-RS-LM1.14
2094715 | 1.NP | xxx.2094715 | A1 | 1.NP | R-RS-LM1.14
2094727 | 1.NP | xxx.2094727 | A1 | 1.NP | R-RS-LM1.14
2094739 | 1.NP | xxx.2094739 | A1 | 1.NP | R-RS-LM1.14
2094753 | 1.NP | xxx.2094753 | A1 | 1.NP | R-RS-LM1.14
2094763 | 1.NP | xxx.2094763 | A1 | 1.NP | R-RS-LM1.14
2094771 | 1.NP | xxx.2094771 | A1 | 1.NP | R-RS-LM1.14
2094781 | 1.NP | xxx.2094781 | A1 | 1.NP | R-RS-LM1.14
2094791 | 1.NP | xxx.2094791 | A1 | 1.NP | R-RS-LM1.13
2094799 | 1.NP | xxx.2094799 | A1 | 1.NP | R-RS-LM1.13
2094807 | 1.NP | xxx.2094807 | A1 | 1.NP | R-RS-LM1.13
2094817 | 1.NP | xxx.2094817 | A1 | 1.NP | R-RS-LM1.13
2094827 | 1.NP | xxx.2094827 | A1 | 1.NP | R-RS-LM1.13
2094849 | 1.NP | xxx.2094849 | A1 | 1.NP | R-RS-LM1.13
2095092 | 1.NP mezipatro | xxx.2095092 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095104 | 1.NP mezipatro | xxx.2095104 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095114 | 1.NP mezipatro | xxx.2095114 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095122 | 1.NP mezipatro | xxx.2095122 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095136 | 1.NP mezipatro | xxx.2095136 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095150 | 1.NP mezipatro | xxx.2095150 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095158 | 1.NP mezipatro | xxx.2095158 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095166 | 1.NP mezipatro | xxx.2095166 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095174 | 1.NP mezipatro | xxx.2095174 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095182 | 1.NP mezipatro | xxx.2095182 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095192 | 1.NP mezipatro | xxx.2095192 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095202 | 1.NP mezipatro | xxx.2095202 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095218 | 1.NP mezipatro | xxx.2095218 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095226 | 1.NP mezipatro | xxx.2095226 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095236 | 1.NP mezipatro | xxx.2095236 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095248 | 1.NP mezipatro | xxx.2095248 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095260 | 1.NP mezipatro | xxx.2095260 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095268 | 1.NP mezipatro | xxx.2095268 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095280 | 1.NP mezipatro | xxx.2095280 | A1 | 1.NP mezipatro | R-RS-LM1.05
2095292 | 1.NP mezipatro | xxx.2095292 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095300 | 1.NP mezipatro | xxx.2095300 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095314 | 1.NP mezipatro | xxx.2095314 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095324 | 1.NP mezipatro | xxx.2095324 | A1 | 1.NP mezipatro | R-RS-LM1.06
2095334 | 1.NP mezipatro | xxx.2095334 | A1 | 1.NP mezipatro | R-RS-LM1.06
2111447 | 1.NP mezipatro | xxx.2111447 | A1 | 1.NP mezipatro | R-RS-LM1.05
2132782 | 2.NP | xxx.2132782 | A1 | 2.NP | R-RS-LM2.13
2135098 | 3.NP | xxx.2135098 | A3 | 3.NP | R-RS-LM3.14
2247183 | 1.NP mezipatro | xxx.2247183 | A9 | 1.NP mezipatro | R-RS-LM1.05
2247680 | 2.NP mezipatro | xxx.2247680 | A11 | 2.NP mezipatro | R-RS-LM2.03
2248306 | 3.NP mezipatro | xxx.2248306 | A12 | 3.NP mezipatro | R-RS-LM3.03
2248927 | 4.NP mezipatro | xxx.2248927 | A13 | 4.NP mezipatro | R-RS-LM4.03

# IfcLightFixture: Světlo LED NB:LED16000-840 L2000 NB (37)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: LED16000-840 L2000 NB; ElementProjectSpecificDescription: světlo přisazené; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: HG; CCI_ComponentsCode: UAC
Pset_DistributionSystemCommon - Reference: R-RS
Name (Světlo LED NB:LED16000-840 L2000 NB:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
2107629 | 4.NP | xxx.2107629 | A1 | 4.NP | R-RS-LM4.14
2107693 | 4.NP | xxx.2107693 | A1 | 4.NP | R-RS-LM4.14
2107770 | 3.NP | xxx.2107770 | A1 | 3.NP | R-RS-LM3.14
2107790 | 3.NP | xxx.2107790 | A1 | 3.NP | R-RS-LM3.14
2107870 | 3.NP | xxx.2107870 | A1 | 3.NP | R-RS-LM3.14
2107898 | 2.NP | xxx.2107898 | A1 | 2.NP | R-RS-LM2.14
2107908 | 2.NP | xxx.2107908 | A1 | 2.NP | R-RS-LM2.14
2107934 | 2.NP | xxx.2107934 | A1 | 2.NP | R-RS-LM2.14
2108019 | 1.NP | xxx.2108019 | A1 | 1.NP | R-RS-LM1.14
2108035 | 1.NP | xxx.2108035 | A1 | 1.NP | R-RS-LM1.14
2108064 | 1.NP | xxx.2108064 | A1 | 1.NP | R-RS-LM1.14
2108162 | 1.S | xxx.2108162 | A1 | 1.S | R-RS-LM0.10
2108182 | 1.S | xxx.2108182 | A1 | 1.S | R-RS-LM0.10
2108242 | 1.S | xxx.2108242 | A1 | 1.S | R-RS-LM0.10
2109920 | 1.S mezipatro | xxx.2109920 | A1 | 1.S mezipatro | R-RS-LM0.13
2109983 | 1.S mezipatro | xxx.2109983 | A1 | 1.S mezipatro | R-RS-LM0.13
2110165 | 1.NP mezipatro | xxx.2110165 | A1 | 1.NP mezipatro | R-RS-LM1.06
2110210 | 1.NP mezipatro | xxx.2110210 | A1 | 1.NP mezipatro | R-RS-LM1.06
2110257 | 2.NP mezipatro | xxx.2110257 | A1 | 2.NP mezipatro | R-RS-LM2.03
2110267 | 2.NP mezipatro | xxx.2110267 | MMMMMMMMMMMMMM | 2.NP mezipatro | R-RS-LM2.03
2110425 | 3.NP mezipatro | xxx.2110425 | A1 | 3.NP mezipatro | R-RS-LM3.03
2111045 | 3.NP mezipatro | xxx.2111045 | A1 | 3.NP mezipatro | R-RS-LM3.03
2111061 | 2.NP mezipatro | xxx.2111061 | A1 | 2.NP mezipatro | R-RS-LM2.03
2111083 | 3.NP mezipatro | xxx.2111083 | A1 | 3.NP mezipatro | R-RS-LM3.03
2111232 | 1.NP mezipatro | xxx.2111232 | A1 | 1.NP mezipatro | R-RS-LM1.06
2111313 | 1.S mezipatro | xxx.2111313 | A1 | 1.S mezipatro | R-RS-LM0.13
2189306 | 4.NP | xxx.2189306 | N10 | 4.NP | R-RS-LM4.14
2235349 | 4.NP mezipatro | xxx.2235349 | A1 | 4.NP mezipatro | R-RS-LM4.03
2235472 | 4.NP mezipatro | xxx.2235472 | A1 | 4.NP mezipatro | R-RS-LM4.03
2235519 | 4.NP mezipatro | xxx.2235519 | A1 | 4.NP mezipatro | R-RS-LM4.03
2235552 | 4.NP mezipatro | xxx.2235552 | A1 | 4.NP mezipatro | R-RS-LM4.03
2235579 | 4.NP mezipatro | xxx.2235579 | A1 | 4.NP mezipatro | R-RS-LM4.04
2235694 | 4.NP mezipatro | xxx.2235694 | A1 | 4.NP mezipatro | R-RS-LM4.04
2235729 | 4.NP mezipatro | xxx.2235729 | A1 | 4.NP mezipatro | R-RS-LM4.04
2235763 | 4.NP mezipatro | xxx.2235763 | A1 | 4.NP mezipatro | R-RS-LM4.04
2235791 | 4.NP mezipatro | xxx.2235791 | A1 | 4.NP mezipatro | R-RS-LM4.04
2367435 | 1.S | xxx.2367435 | A104 | 1.S | R-RS-LM0.11

# IfcLightFixture: světlo chodba vzor:1270x95, přisazené (24)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 1270x95, přisazené; ElementProjectSpecificDescription: Svítidlo přisazené LED 43W; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: svítidlo ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: Q; CCI_TechnicalSystemsCode: HH; CCI_ComponentsCode: UAC
Pset_DistributionSystemCommon - Reference: R-RS
Name (světlo chodba vzor:1270x95, přisazené:...) | In | CZ_ElementCommon, Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
2103698 | 1.NP mezipatro | xxx.2103698 | A2 | 1.NP mezipatro | R-RS-LM1.01
2103737 | 1.NP mezipatro | xxx.2103737 | A2 | 1.NP mezipatro | R-RS-LM1.01
2103791 | 1.NP | xxx.2103791 | A2 | 1.NP | R-RS-LM1.01
2103912 | 1.S | xxx.2103912 | A2 | 1.S | R-RS-LM1.01
2103943 | 1.S | xxx.2103943 | A2 | 1.S | R-RS-LM1.01
2103998 | 1.S mezipatro | xxx.2103998 | A2 | 1.S mezipatro | R-RS-LM1.01
2104020 | 1.S mezipatro | xxx.2104020 | A2 | 1.S mezipatro | R-RS-LM1.01
2104090 | 2.NP mezipatro | xxx.2104090 | FFFFF | 2.NP mezipatro | R-RS-LM1.01
2104101 | 2.NP mezipatro | xxx.2104101 | GGGGG | 2.NP mezipatro | R-RS-LM1.01
2104114 | 3.NP mezipatro | xxx.2104114 | HHHHH | 3.NP mezipatro | R-RS-LM1.01
2104129 | 3.NP mezipatro | xxx.2104129 | IIIII | 3.NP mezipatro | R-RS-LM1.01
2104175 | 4.NP mezipatro | xxx.2104175 | LLLLL | 4.NP mezipatro | R-RS-LM1.01
2104186 | 4.NP mezipatro | xxx.2104186 | MMMMM | 4.NP mezipatro | R-RS-LM1.01
2104269 | 4.NP | xxx.2104269 | PPPPPP | 4.NP | R-RS-LM1.01
2104294 | 4.NP | xxx.2104294 | TTTTTT | 4.NP | R-RS-LM1.01
2104349 | 3.NP | xxx.2104349 | UUUUUU | 3.NP | R-RS-LM1.01
2104360 | 3.NP | xxx.2104360 | BBBBBBBB | 3.NP | R-RS-LM1.01
2104382 | 2.NP | xxx.2104382 | CCCCCCCC | 2.NP | R-RS-LM1.01
2104392 | 2.NP | xxx.2104392 | GGGGGGGGGGGG | 2.NP | R-RS-LM1.01
2104436 | 1.NP | xxx.2104436 | A2 | 1.NP | R-RS-LM1.01
2416704 | 1.S | xxx.2416704 | A2 | 1.S | R-RS-LM1.02
2416875 | 1.S | xxx.2416875 | A2 | 1.S | R-RS-LM1.02
2422924 | 1.S mezipatro | xxx.2422924 | A2 | 1.S mezipatro | R-RS-LM1.02
2422938 | 1.S mezipatro | xxx.2422938 | A2 | 1.S mezipatro | R-RS-LM1.02
