Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: , VersionGUID: 59de9ca4-9700-4494-b448-8fc868edccf0, NumberOfSaves: 91], ExchangeRequirement [BuildingService], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: SO01-ZTI-KAN.ifc
Time: 2025-04-10T13:02:28+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (CSY) - IFC 23.4.1.0

# IfcProject, ZDE ZADEJTE ČÍSLO PROJEKTU
LongName: ZDE ZADEJTE NÁZEV PROJEKTU; Phase: ZDE ZADEJTE STUPEŇ PD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Informace o projektu

# IfcBuilding
Pset_BuildingCommon - Reference: Informace o projektu; NumberOfStoreys: 6
Pset_BuildingElementProxyCommon - Reference: Informace o projektu; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informace o projektu; sets with these values: 2

# IfcBuildingStorey: Podlaží:0,000, 1.S
LongName: 1.S; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 0,000

# IfcBuildingStorey: Podlaží:Podlaží (12)
Pset_BuildingStoreyCommon - Reference: Podlaží
Name | LongName | Elevation (mm)
1.S mezipatro | 1.S mezipatro | 1500
1.NP | 1.NP | 3000
1.NP mezipatro | 1.NP mezipatro | 4500
2.NP | 2.NP | 6000
2.NP mezipatro | 2.NP mezipatro | 7500
3.NP | 3.NP | 9000
3.NP mezipatro | 3.NP mezipatro | 10500
4.NP | 4.NP | 12000
4.NP mezipatro | 4.NP mezipatro | 13500
5.NP | 5.NP | 15000
5.NP mezipatro | 5.NP mezipatro | 16500
Střecha | Střecha | 20200

# IfcDistributionPort (475)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection | SystemType | Group
InPort_904547_1 | SINK | SEWAGE
OutPort_904545_1 | SOURCE | SEWAGE
Port_904547_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929413_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_924944_0 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_908165_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_915316_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_924103_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_918702_1 | SINK | SEWAGE
OutPort_918693_1 | SOURCE | SEWAGE
Port_918702_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_937148_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
OutPort_921212_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_924103_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926234_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_924944_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926320_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_925565_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926692_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_925565_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926320_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926116_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926307_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926116_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939133_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926234_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926250_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926250_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926312_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926260_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926307_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926260_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926312_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926307_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926308_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926308_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926316_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926316_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934326_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926316_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926693_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926343_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930078_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926343_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926702_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926504_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926692_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926504_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926702_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926692_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_926693_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929413_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930241_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929417_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929727_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929417_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929744_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929727_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929744_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_929769_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_929769_2 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_930079_0 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_930068_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930078_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930068_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930100_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930078_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930079_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930100_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_930241_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_933763_0 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_933575_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_933763_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_933911_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_933828_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_933911_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_933828_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934545_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934315_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934325_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934315_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934545_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934325_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934326_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_934325_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_935562_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_934545_2 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_933828_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_935562_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_972473_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_980928_0 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_936814_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_937148_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_937327_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973644_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_937327_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973435_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_938543_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973645_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939098_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957892_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939098_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939125_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939128_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939125_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939133_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939128_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939903_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939726_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973858_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939726_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973875_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939787_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973858_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939787_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939812_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939801_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939812_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939801_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939825_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939816_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939825_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939816_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939902_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939902_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957893_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939902_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_939903_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_940421_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940541_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940421_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940512_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967166_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940512_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940541_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940532_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967166_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940532_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967170_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_940679_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969269_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940679_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940712_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969263_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940712_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969269_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940725_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969263_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940725_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940854_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969656_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_940854_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941028_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969654_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941028_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969656_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941041_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941043_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941041_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969654_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941043_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_962384_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941043_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941044_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_941044_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_943406_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_942454_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_943163_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_943176_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_943189_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_943241_1 | SOURCEANDSINK
Port_943338_1 | SOURCEANDSINK
Port_945799_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975465_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_945799_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_951056_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978253_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_951056_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965879_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_951936_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965879_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_951936_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952610_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952286_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952695_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952286_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953109_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952601_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952604_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952601_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952610_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952604_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953206_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952685_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952695_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952685_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952841_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952695_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952696_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952696_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974918_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952727_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952841_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952727_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952874_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952848_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_961739_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952848_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_952874_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953101_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953109_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953101_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953205_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953176_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953205_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953176_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953205_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_953206_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
InPort_957616_0 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_957035_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_957616_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957637_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957626_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957637_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957626_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957670_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957658_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957670_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957658_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957826_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957810_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957826_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957810_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957924_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957867_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957902_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957867_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957919_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957888_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957892_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957888_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957897_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957889_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957897_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957889_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957902_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957892_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957893_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957916_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957919_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957916_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_957924_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_958289_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968840_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_958289_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_959606_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967557_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_959606_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_969984_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_961072_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_961072_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970875_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_961501_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966280_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_961501_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_961739_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_961743_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
InPort_961743_2 | SINK | SEWAGE | Kanalizace_Dešťová 2
OutPort_971478_0 | SOURCE | SEWAGE | Kanalizace_Dešťová 2
Port_962384_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964318_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_963240_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965063_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_963240_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_963829_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966280_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_963829_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966287_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_963880_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966287_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_963880_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964024_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964024_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964330_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964310_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964318_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964310_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964330_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964318_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964319_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964319_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_972002_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964537_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965063_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_964537_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965067_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965067_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970734_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_965067_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969264_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966280_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966281_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_966281_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971477_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_967064_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967170_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967064_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967170_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967171_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967171_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968844_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967546_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967557_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967546_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967633_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967633_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_972838_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_967633_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968845_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968748_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968840_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968748_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968844_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968844_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_968845_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_969263_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969264_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_969976_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_969984_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_969976_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_970677_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970797_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970677_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970867_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970734_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970797_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970797_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970798_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970798_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978038_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970867_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_970875_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971312_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971477_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971312_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971483_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971382_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971382_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971483_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971477_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971478_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971603_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971603_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971617_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971611_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971617_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971611_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971803_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971791_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971803_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971791_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971998_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971808_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971998_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_971808_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_972002_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_972002_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_972003_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_972003_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974563_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_972455_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_972473_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_972455_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_972477_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_972477_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980815_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_972838_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975146_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_973383_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973569_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973383_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_973435_2 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_973718_0 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_973569_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973652_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973603_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973644_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973603_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973652_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973644_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973645_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
InPort_973652_2 | SINK | SEWAGE | Kanalizace_Splašková 1
OutPort_973569_1 | SOURCE | SEWAGE | Kanalizace_Splašková 1
Port_973718_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973879_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973872_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973875_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973872_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_973879_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_974060_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_976744_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974060_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974914_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974174_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974914_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974174_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_974918_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
InPort_974634_0 | SINK | SEWAGE | Kanalizace_Dešťová 2
OutPort_974563_1 | SOURCE | SEWAGE | Kanalizace_Dešťová 2
InPort_974563_2 | SINK | SEWAGE | Kanalizace_Dešťová 2
OutPort_972003_1 | SOURCE | SEWAGE | Kanalizace_Dešťová 2
Port_974634_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975086_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975026_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_976740_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975026_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_976744_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975077_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_976740_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975077_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975086_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_975135_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975146_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975135_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975161_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975150_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975161_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975150_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975263_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975255_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975263_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975255_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_978569_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
InPort_975263_2 | SINK | SEWAGE | Kanalizace_Dešťová 1
OutPort_975255_0 | SOURCE | SEWAGE | Kanalizace_Dešťová 1
Port_975423_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975465_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_975423_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_978565_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_978030_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978038_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978030_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978249_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978068_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978249_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978068_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978251_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978251_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
Port_978253_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 2
InPort_978253_2 | SINK | SEWAGE | Kanalizace_Dešťová 2
OutPort_978251_1 | SOURCE | SEWAGE | Kanalizace_Dešťová 2
Port_978367_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_978565_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_978367_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_978569_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Dešťová 1
Port_980800_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980927_3 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980800_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980962_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980815_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980927_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980927_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980928_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980944_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980962_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980944_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_982621_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980966_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_982621_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
Port_980966_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 1
OutPort_981075_1 | SOURCE | SEWAGE | Kanalizace_Splašková 2
Port_981352_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 2
Port_981922_0 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 2
Port_981352_2 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 2
Port_981922_1 | SOURCEANDSINK | SEWAGE | Kanalizace_Splašková 2

# IfcDistributionSystem: Kanalizace_Dešťová (2)
PredefinedType: SEWAGE
Pset_DistributionSystemCommon - Reference: Kanalizace_Dešťová
Name
Kanalizace_Dešťová 1
Kanalizace_Dešťová 2

# IfcDistributionSystem: Kanalizace_Splašková (2)
PredefinedType: SEWAGE
Pset_DistributionSystemCommon - Reference: Kanalizace_Splašková
Name
Kanalizace_Splašková 1
Kanalizace_Splašková 2

# IfcFlowTerminal: Invalida_Umyvadlo.CC :Invalida_Umyvadlo.CC, Invalida_Umyvadlo.CC :Invalida_Umyvadlo.CC:904545
In: 1.S
Type - Material: <Unnamed>, ZDRAVOTNÍ KERAMIKA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: UI; ElementProjectSpecificDescription: Invalida_Umyvadlo.CC , Invalida_Umyvadlo.CC
Pset_EnvironmentalImpactIndicators - Reference: Invalida_Umyvadlo.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Invalida_Umyvadlo.CC; ElementProjectObjectIdentifier: SO 01; Reference: UI.01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P

# IfcFlowTerminal: Invalida_WC závěsné pro předstěny.CC:Invalida_WC závěsné pro předstěny.CC, Invalida_WC závěsné pro předstěny.CC:Invalida_WC závěsné pro předstěny.CC:908165
In: 1.S
Type - Material: ZDRAVOTNÍ KERAMIKA, PLAST_BÍLÝ
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: WCI; ElementProjectSpecificDescription: Invalida_WC závěsné pro předstěny.CC, Invalida_WC závěsné pro předstěny.CC
Pset_EnvironmentalImpactIndicators - Reference: Invalida_WC závěsné pro předstěny.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Invalida_WC závěsné pro předstěny.CC; ElementProjectObjectIdentifier: SO 01; Reference: WCI.02; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P
Group: Kanalizace_Splašková 1

# IfcFlowTerminal: Předstěn.instal. Special pro WC a madla, s nádržkou, pro TP.CC:Předstěn.instal. pro WC a madla, s nádržkou, pro TP.CC, Předstěn.instal. Special pro WC a madla, s nádržkou, pro TP.CC:Předstěn.instal. pro WC a madla, s nádržkou, pro TP.CC:908164
In: 1.S
Type - Material: <Unnamed>, PLAST_BÍLÝ
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: WCI; ElementProjectSpecificDescription: Předstěn.instal. pro WC a madla, s nádržkou, pro TP.CC, Předstěn.instal.pro WC a madla, s nádržkou, pro TP.CC
Pset_EnvironmentalImpactIndicators - Reference: Předstěn.instal. pro WC a madla, s nádržkou, pro TP.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Předstěn.instal. pro WC a madla, s nádržkou, pro TP.CC; ElementProjectObjectIdentifier: SO 01; Reference: WCI.05; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P

# IfcFlowTerminal: Předstěn.instal. pro WC 112cm, s nádrží 12cm - lehká kce.CC:Předstěn.instal. pro WC 112cm, s nádrží 12cm, Předstěn.instal. pro WC 112cm, s nádrží 12cm - lehká kce.CC:Předstěn.instal. pro WC 112cm, s nádrží 12cm:915317
In: 1.S
Type - Material: PLAST_BÍLÝ, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: WC; ElementProjectSpecificDescription: Předstěn.instal. pro WC 112cm, s nádrží12cm - lehká kce.CC, Předstěn.instal. pro WC 112cm, s nádrží 12cm
Pset_EnvironmentalImpactIndicators - Reference: Předstěn.instal. pro WC 112cm, s nádrží 12cm
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Předstěn.instal. pro WC 112cm, s nádrží 12cm; ElementProjectObjectIdentifier: SO 01; Reference: WC.04; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P

# IfcFlowTerminal: Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC:Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC, Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC:Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC:921210
In: 1.S
Type - Material: <Unnamed>, PLAST_BÍLÝ
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: Pi; ElementProjectSpecificDescription: Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC, Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC
Pset_EnvironmentalImpactIndicators - Reference: Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Předstěn.instal. pro pisoár 112-130 cm Universal - lehká kce.CC; ElementProjectObjectIdentifier: SO 01; Reference: Pi.03; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P

# IfcFlowTerminal: Retenční nádrž1:Retenční nádrž, Retenční nádrž1:Retenční nádrž:944806
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: RN; ElementProjectSpecificDescription: Retenční nádrž
Pset_EnvironmentalImpactIndicators - Reference: Retenční nádrž
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: GPA
CZ_ElementCommon - ElementProjectSpecificName: Retenční nádrž; ElementProjectObjectIdentifier: SO 01; Reference: RN.07; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zásobní nádrž užitkové vody RUV; DT_code: RUV.ST.N
Pset_TankTypeCommon - EffectiveCapacity: 60.12 m3

# IfcFlowTerminal: Retenční nádrž:Retenční nádrž, Retenční nádrž:Retenční nádrž:943769
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: RN; ElementProjectSpecificDescription: Retenční nádrž
Pset_EnvironmentalImpactIndicators - Reference: Retenční nádrž
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: GPA
CZ_ElementCommon - ElementProjectSpecificName: Retenční nádrž; ElementProjectObjectIdentifier: SO 01; Reference: RN.06; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zásobní nádrž užitkové vody RUV; DT_code: RUV.ST.N
Pset_TankTypeCommon - EffectiveCapacity: 60.12 m3

# IfcFlowTerminal: Střešní vpust.CC:VP (7)
In: Střecha
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ARM; ElementProjectSpecificDescription: Vpusť
Pset_EnvironmentalImpactIndicators - Reference: VP
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: VP; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: Střecha
CZ_DTcommon - DT_name: vpusti KAN; DT_code: KAN.KP.V
Name (Střešní vpust.CC:VP:...) | Reference | Group
942454 | ARM.09 | Kanalizace_Dešťová 1
943163 | ARM.10 | Kanalizace_Dešťová 1
943176 | ARM.11 | Kanalizace_Dešťová 2
943189 | ARM.12 | Kanalizace_Dešťová 2
943241 | ARM.13
943338 | ARM.14
943406 | ARM.15 | Kanalizace_Dešťová 2

# IfcFlowTerminal: Umyvadlo.CC:Umyvadlo.CC, Umyvadlo.CC:Umyvadlo.CC:918693
In: 1.S
Type - Material: <Unnamed>, PLAST_BÍLÝ
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: U; ElementProjectSpecificDescription: Umyvadlo.CC, Umyvadlo.CC
Pset_EnvironmentalImpactIndicators - Reference: Umyvadlo.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Umyvadlo.CC; ElementProjectObjectIdentifier: SO 01; Reference: U.08; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P

# IfcFlowTerminal: Výlevka.CC:Výlevka.CC, Výlevka.CC:Výlevka.CC:957035
In: 1.S
Type - Material: ZDRAVOTNÍ KERAMIKA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VYL; ElementProjectSpecificDescription: Výlevka
Pset_EnvironmentalImpactIndicators - Reference: Výlevka.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: Výlevka.CC; ElementProjectObjectIdentifier: SO 01; Reference: VYL.16; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P
Group: Kanalizace_Splašková 1

# IfcFlowTerminal: WC tlačítko.CC:WC tlačítko.CC (3)
In: 1.S
Type - Material: PLAST_BÍLÝ
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: WC; ElementProjectSpecificDescription: WC tlačítko.CC, WC tlačítko.CC
Pset_EnvironmentalImpactIndicators - Reference: WC tlačítko.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: WC tlačítko.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P
Name (WC tlačítko.CC:WC tlačítko.CC:...) | Reference
908168 | WC.17
908169 | WC.18
979347 | WC.19

# IfcFlowTerminal: WC_Pisoár se zadním přívodem vody se sifonem.CC:WC_Pisoár se zadním přívodem vody se sifonem.CC, WC_Pisoár se zadním přívodem vody se sifonem.CC:WC_Pisoár se zadním přívodem vody se sifonem.CC:921212
In: 1.S
Type - Material: <Unnamed>, ZDRAVOTNÍ KERAMIKA
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: Pi; ElementProjectSpecificDescription: WC_Pisoár se zadním přívodem vody se sifonem.CC, WC_Pisoár se zadním přívodem vody se sifonem.CC
Pset_EnvironmentalImpactIndicators - Reference: WC_Pisoár se zadním přívodem vody se sifonem.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: WC_Pisoár se zadním přívodem vody se sifonem.CC; ElementProjectObjectIdentifier: SO 01; Reference: Pi.20; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P
Group: Kanalizace_Splašková 1

# IfcFlowTerminal: WC_Zavěšené pro předstěnu.CC:WC_Zavěšené pro předstěnu.CC, WC_Zavěšené pro předstěnu.CC:WC_Zavěšené pro předstěnu.CC:915316
In: 1.S
Type - Material: ZDRAVOTNÍ KERAMIKA, PLAST_BÍLÝ
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: WC; ElementProjectSpecificDescription: WC_Zavěšené pro předstěnu.CC, WC_Zavěšené pro předstěnu.CC
Pset_EnvironmentalImpactIndicators - Reference: WC_Zavěšené pro předstěnu.CC
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: XKA
CZ_ElementCommon - ElementProjectSpecificName: WC_Zavěšené pro předstěnu.CC; ElementProjectObjectIdentifier: SO 01; Reference: WC.21; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: KAN.KP.P
Group: Kanalizace_Splašková 1

# IfcPipeFitting: HT_Koleno HTB.CC:HT_Koleno HTB.CC (53)
Type - Material: Pipes_HT System PP, Trubky_HT Systém PP
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Koleno
Pset_EnvironmentalImpactIndicators - Reference: HT_Koleno HTB.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HT_Koleno HTB.CC; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (HT_Koleno HTB.CC:HT_Koleno HTB.CC:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
926234 | 1.S | TR.148 | 1.S | Kanalizace_Splašková 1
926312 | 1.S | TR.149 | 1.S | Kanalizace_Splašková 1
926320 | 1.S | TR.150 | 1.S | Kanalizace_Splašková 1
926702 | 1.S | TR.151 | 1.S | Kanalizace_Splašková 1
929413 | 1.S | TR.152 | 1.S | Kanalizace_Splašková 1
929727 | 1.S | TR.153 | 1.S | Kanalizace_Splašková 1
929744 | 1.S | TR.154 | 1.S | Kanalizace_Splašková 1
930100 | 1.S | TR.155 | 1.S | Kanalizace_Splašková 1
933911 | 1.S | TR.156 | 1.S | Kanalizace_Splašková 1
940541 | Střecha | TR.157 | Střecha | Kanalizace_Dešťová 1
952604 | 1.S | TR.158 | 1.S | Kanalizace_Dešťová 2
952610 | 1.S | TR.159 | 1.S | Kanalizace_Dešťová 2
952841 | 1.S | TR.160 | 1.S | Kanalizace_Dešťová 2
952874 | 5.NP mezipatro | TR.161 | 5.NP mezipatro | Kanalizace_Dešťová 2
953109 | 5.NP mezipatro | TR.162 | 5.NP mezipatro | Kanalizace_Dešťová 2
957637 | 1.S mezipatro | TR.163 | 1.S mezipatro | Kanalizace_Splašková 1
957670 | 1.S mezipatro | TR.164 | 1.S mezipatro | Kanalizace_Splašková 1
961739 | 5.NP mezipatro | TR.165 | 5.NP mezipatro | Kanalizace_Dešťová 2
964330 | 5.NP | TR.166 | 5.NP | Kanalizace_Dešťová 2
965063 | 5.NP | TR.167 | 5.NP | Kanalizace_Dešťová 2
965879 | 1.S | TR.168 | 1.S | Kanalizace_Dešťová 2
966287 | 5.NP | TR.169 | 5.NP | Kanalizace_Dešťová 2
967166 | Střecha | TR.170 | Střecha | Kanalizace_Dešťová 1
967557 | 4.NP mezipatro | TR.171 | 4.NP mezipatro | Kanalizace_Dešťová 1
968840 | 4.NP mezipatro | TR.172 | 4.NP mezipatro | Kanalizace_Dešťová 1
969269 | 5.NP mezipatro | TR.173 | 5.NP mezipatro | Kanalizace_Dešťová 2
969654 | 5.NP mezipatro | TR.174 | 5.NP mezipatro | Kanalizace_Dešťová 2
969656 | 5.NP mezipatro | TR.175 | 5.NP mezipatro | Kanalizace_Dešťová 2
969984 | 4.NP mezipatro | TR.176 | 4.NP mezipatro | Kanalizace_Dešťová 1
970875 | 5.NP | TR.177 | 5.NP | Kanalizace_Dešťová 2
971483 | 4.NP mezipatro | TR.178 | 4.NP mezipatro | Kanalizace_Dešťová 2
971617 | 4.NP mezipatro | TR.179 | 4.NP mezipatro | Kanalizace_Dešťová 2
971803 | 4.NP mezipatro | TR.180 | 4.NP mezipatro | Kanalizace_Dešťová 2
971998 | 4.NP mezipatro | TR.181 | 4.NP mezipatro | Kanalizace_Dešťová 2
972473 | 1.S | TR.182 | 1.S | Kanalizace_Splašková 1
972477 | 1.S | TR.183 | 1.S | Kanalizace_Splašková 1
973383 | 1.S | TR.184 | 1.S | Kanalizace_Splašková 1
973879 | 1.S | TR.185 | 1.S | Kanalizace_Splašková 1
974914 | 1.S | TR.186 | 1.S | Kanalizace_Dešťová 2
974918 | 5.NP mezipatro | TR.187 | 5.NP mezipatro | Kanalizace_Dešťová 2
975086 | 5.NP mezipatro | TR.188 | 5.NP mezipatro | Kanalizace_Dešťová 2
975146 | 5.NP mezipatro | TR.189 | 5.NP mezipatro | Kanalizace_Dešťová 1
975161 | 5.NP mezipatro | TR.190 | 5.NP mezipatro | Kanalizace_Dešťová 1
975465 | 1.S | TR.191 | 1.S | Kanalizace_Dešťová 1
976744 | 1.S | TR.193 | 1.S | Kanalizace_Dešťová 2
978038 | 1.S | TR.194 | 1.S | Kanalizace_Dešťová 2
978249 | 1.S | TR.195 | 1.S | Kanalizace_Dešťová 2
978251 | 5.NP mezipatro | TR.196 | 5.NP mezipatro | Kanalizace_Dešťová 2
978565 | 5.NP mezipatro | TR.197 | 5.NP mezipatro | Kanalizace_Dešťová 1
978569 | 5.NP mezipatro | TR.198 | 5.NP mezipatro | Kanalizace_Dešťová 1
980962 | 5.NP mezipatro | TR.200 | 5.NP mezipatro | Kanalizace_Splašková 1
981352 | 5.NP mezipatro | TR.201 | 5.NP mezipatro | Kanalizace_Splašková 2
982621 | 5.NP mezipatro | TR.202 | 5.NP mezipatro | Kanalizace_Splašková 1

# IfcPipeFitting: HT_Koleno HTB.CC:HT_Koleno HTB.CC, HT_Koleno HTB.CC:HT_Koleno HTB.CC:976740
In: 1.S
Type - Material: Warnings, Pipes_HT System PP, Trubky_HT Systém PP
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Koleno
Pset_EnvironmentalImpactIndicators - Reference: HT_Koleno HTB.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HT_Koleno HTB.CC; ElementProjectObjectIdentifier: SO 01; Reference: TR.192; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Dešťová 2

# IfcPipeFitting: HT_Odbočka HTEA.CC:HT_Odbočka HTEA.CC (19)
Type - Material: Pipes_HT System PP
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Odbočka
Pset_EnvironmentalImpactIndicators - Reference: HT_Odbočka HTEA.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HT_Odbočka HTEA.CC; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (HT_Odbočka HTEA.CC:HT_Odbočka HTEA.CC:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
926307 | 1.S | TR.203 | 1.S | Kanalizace_Splašková 1
926316 | 1.S | TR.204 | 1.S | Kanalizace_Splašková 1
926692 | 1.S | TR.205 | 1.S | Kanalizace_Splašková 1
930078 | 1.S | TR.206 | 1.S | Kanalizace_Splašková 1
934325 | 1.S | TR.207 | 1.S | Kanalizace_Splašková 1
941043 | 5.NP mezipatro | TR.208 | 5.NP mezipatro | Kanalizace_Dešťová 2
952695 | 1.S | TR.209 | 1.S | Kanalizace_Dešťová 2
953205 | 1.S | TR.210 | 1.S | Kanalizace_Dešťová 2
964318 | 5.NP | TR.211 | 5.NP | Kanalizace_Dešťová 2
965067 | 5.NP | TR.212 | 5.NP | Kanalizace_Dešťová 2
966280 | 5.NP | TR.213 | 5.NP | Kanalizace_Dešťová 2
967170 | Střecha | TR.214 | Střecha | Kanalizace_Dešťová 1
967633 | 5.NP mezipatro | TR.215 | 5.NP mezipatro | Kanalizace_Dešťová 1
968844 | 4.NP mezipatro | TR.216 | 4.NP mezipatro | Kanalizace_Dešťová 1
969263 | 5.NP mezipatro | TR.217 | 5.NP mezipatro | Kanalizace_Dešťová 2
970797 | 1.S | TR.218 | 1.S | Kanalizace_Dešťová 2
971477 | 4.NP mezipatro | TR.219 | 4.NP mezipatro | Kanalizace_Dešťová 2
972002 | 4.NP mezipatro | TR.220 | 4.NP mezipatro | Kanalizace_Dešťová 2
973644 | 1.S | TR.221 | 1.S | Kanalizace_Splašková 1

# IfcPipeFitting: HT_Odbočka HTEA.CC:HT_Odbočka HTEA.CC, HT_Odbočka HTEA.CC:HT_Odbočka HTEA.CC:980927
In: 5.NP mezipatro
Type - Material: Pipes_HT System PP, Warnings
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Odbočka
Pset_EnvironmentalImpactIndicators - Reference: HT_Odbočka HTEA.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HT_Odbočka HTEA.CC; ElementProjectObjectIdentifier: SO 01; Reference: TR.222; StoreyProjectSpecificIdentifier: 5.NP mezipatro
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Splašková 1

# IfcPipeFitting: HT_Redukce HTR.CC:HT_Redukce HTR.CC (6)
Type - Material: Pipes_HT System PP
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Redukce
Pset_EnvironmentalImpactIndicators - Reference: HT_Redukce HTR.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HT_Redukce HTR.CC; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (HT_Redukce HTR.CC:HT_Redukce HTR.CC:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
929769 | 1.S | TR.223 | 1.S | Kanalizace_Splašková 1
934545 | 1.S | TR.224 | 1.S | Kanalizace_Splašková 1
973435 | 1.S | TR.226 | 1.S | Kanalizace_Splašková 1
974563 | 5.NP mezipatro | TR.228 | 5.NP mezipatro | Kanalizace_Dešťová 2
975263 | 5.NP mezipatro | TR.229 | 5.NP mezipatro | Kanalizace_Dešťová 1
978253 | 5.NP mezipatro | TR.230 | 5.NP mezipatro | Kanalizace_Dešťová 2

# IfcPipeFitting: HT_Redukce HTR.CC:HT_Redukce HTR.CC (2)
Type - Material: Pipes_HT System PP, Warnings
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Redukce
Pset_EnvironmentalImpactIndicators - Reference: HT_Redukce HTR.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HT_Redukce HTR.CC; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (HT_Redukce HTR.CC:HT_Redukce HTR.CC:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
961743 | 5.NP mezipatro | TR.225 | 5.NP mezipatro | Kanalizace_Dešťová 2
973652 | 1.S | TR.227 | 1.S | Kanalizace_Splašková 1

# IfcPipeFitting: KGB_Koleno.CC:KGB_Koleno.CC (11)
Type - Material: Trubky_KG Systém PVC
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Koleno
Pset_EnvironmentalImpactIndicators - Reference: KGB_Koleno.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: KGB_Koleno.CC; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Splašková 1
Name (KGB_Koleno.CC:KGB_Koleno.CC:...) | In | Reference | StoreyProjectSpecificIdentifier
939128 | 1.S | TR.231 | 1.S
939133 | 1.S | TR.232 | 1.S
939812 | 1.S | TR.233 | 1.S
939825 | 1.S | TR.234 | 1.S
957826 | 1.S mezipatro | TR.235 | 1.S mezipatro
957897 | 1.S | TR.236 | 1.S
957902 | 1.S | TR.237 | 1.S
957919 | 1.S | TR.238 | 1.S
957924 | 1.S mezipatro | TR.239 | 1.S mezipatro
973858 | 1.S | TR.240 | 1.S
973875 | 1.S | TR.241 | 1.S

# IfcPipeFitting: KGEA_Odbočka.CC:KGEA_Odbočka.CC (2)
In: 1.S
Type - Material: Trubky_KG Systém PVC
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Odbočka
Pset_EnvironmentalImpactIndicators - Reference: KGEA_Odbočka.CC; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: KGEA_Odbočka.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Splašková 1
Name (KGEA_Odbočka.CC:KGEA_Odbočka.CC:...) | Reference
939902 | TR.242
957892 | TR.243

# IfcPipeSegment: Typy trubek:Plast - HT (101)
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Trubka
Pset_EnvironmentalImpactIndicators - Reference: Plast - HT; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Plast - HT; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Name (Typy trubek:Plast - HT:...) | In | Reference | StoreyProjectSpecificIdentifier | Length (mm) | Group
924103 | 1.S | TR.30 | 1.S | 109 | Kanalizace_Splašková 1
924944 | 1.S | TR.31 | 1.S | 74 | Kanalizace_Splašková 1
925565 | 1.S | TR.32 | 1.S | 85.2789 | Kanalizace_Splašková 1
926250 | 1.S | TR.33 | 1.S | 166 | Kanalizace_Splašková 1
926260 | 1.S | TR.34 | 1.S | 113.603 | Kanalizace_Splašková 1
926308 | 1.S | TR.35 | 1.S | 154.578 | Kanalizace_Splašková 1
926343 | 1.S | TR.36 | 1.S | 33.7966 | Kanalizace_Splašková 1
926504 | 1.S | TR.37 | 1.S | 55.1316 | Kanalizace_Splašková 1
926693 | 1.S | TR.38 | 1.S | 119.404 | Kanalizace_Splašková 1
929417 | 1.S | TR.39 | 1.S | 73.834 | Kanalizace_Splašková 1
930068 | 1.S | TR.40 | 1.S | 77.3269 | Kanalizace_Splašková 1
930079 | 1.S | TR.41 | 1.S | 167.443 | Kanalizace_Splašková 1
930241 | 1.S | TR.42 | 1.S | 1589.59 | Kanalizace_Splašková 1
933763 | 1.S | TR.43 | 1.S | 49 | Kanalizace_Splašková 1
933828 | 1.S | TR.44 | 1.S | 494.654 | Kanalizace_Splašková 1
934315 | 1.S | TR.45 | 1.S | 16.3663 | Kanalizace_Splašková 1
934326 | 1.S | TR.46 | 1.S | 1055.8 | Kanalizace_Splašková 1
935562 | 1.S | TR.47 | 1.S | 1558.99 | Kanalizace_Splašková 1
937148 | 1.S | TR.48 | 1.S | 101.518 | Kanalizace_Splašková 1
937327 | 1.S | TR.49 | 1.S | 362.491 | Kanalizace_Splašková 1
940421 | Střecha | TR.50 | Střecha | 246.273 | Kanalizace_Dešťová 1
940512 | Střecha | TR.51 | Střecha | 2593.93 | Kanalizace_Dešťová 1
940532 | Střecha | TR.52 | Střecha | 443.252 | Kanalizace_Dešťová 1
940679 | 5.NP mezipatro | TR.53 | 5.NP mezipatro | 132 | Kanalizace_Dešťová 2
940712 | 5.NP mezipatro | TR.54 | 5.NP mezipatro | 7507.04 | Kanalizace_Dešťová 2
940725 | 5.NP mezipatro | TR.55 | 5.NP mezipatro | 206.381 | Kanalizace_Dešťová 2
940854 | 5.NP mezipatro | TR.56 | 5.NP mezipatro | 154.282 | Kanalizace_Dešťová 2
941028 | 5.NP mezipatro | TR.57 | 5.NP mezipatro | 2751.99 | Kanalizace_Dešťová 2
941041 | 5.NP mezipatro | TR.58 | 5.NP mezipatro | 376.99 | Kanalizace_Dešťová 2
941044 | 5.NP mezipatro | TR.59 | 5.NP mezipatro | 242.357 | Kanalizace_Dešťová 2
945799 | 1.S | TR.60 | 1.S | 13599.1 | Kanalizace_Dešťová 1
951056 | 5.NP mezipatro | TR.61 | 5.NP mezipatro | 1667.88 | Kanalizace_Dešťová 2
951936 | 1.S | TR.62 | 1.S | 10087.2 | Kanalizace_Dešťová 2
952286 | 5.NP mezipatro | TR.63 | 5.NP mezipatro | 1902.93 | Kanalizace_Dešťová 2
952601 | 1.S | TR.64 | 1.S | 266.344 | Kanalizace_Dešťová 2
952685 | 1.S | TR.65 | 1.S | 478.43 | Kanalizace_Dešťová 2
952696 | 5.NP mezipatro | TR.66 | 5.NP mezipatro | 9428.07 | Kanalizace_Dešťová 2
952727 | 1.S | TR.67 | 1.S | 1795.34 | Kanalizace_Dešťová 2
952848 | 5.NP mezipatro | TR.68 | 5.NP mezipatro | 546.077 | Kanalizace_Dešťová 2
953101 | 1.S | TR.69 | 1.S | 379.872 | Kanalizace_Dešťová 2
953176 | 1.S | TR.70 | 1.S | 16212.7 | Kanalizace_Dešťová 2
953206 | 1.S | TR.71 | 1.S | 925.267 | Kanalizace_Dešťová 2
957616 | 1.S mezipatro | TR.72 | 1.S mezipatro | 34.1236 | Kanalizace_Splašková 1
957626 | 1.S mezipatro | TR.73 | 1.S mezipatro | 226.189 | Kanalizace_Splašková 1
957658 | 1.S mezipatro | TR.74 | 1.S mezipatro | 428.246 | Kanalizace_Splašková 1
958289 | 4.NP mezipatro | TR.75 | 4.NP mezipatro | 234.003 | Kanalizace_Dešťová 1
959606 | 4.NP mezipatro | TR.76 | 4.NP mezipatro | 10253.5 | Kanalizace_Dešťová 1
961072 | 5.NP | TR.77 | 5.NP | 236.541 | Kanalizace_Dešťová 2
961501 | 5.NP mezipatro | TR.78 | 5.NP mezipatro | 4134.44 | Kanalizace_Dešťová 2
962384 | 5.NP mezipatro | TR.79 | 5.NP mezipatro | 3621 | Kanalizace_Dešťová 2
963240 | 5.NP | TR.80 | 5.NP | 292.217 | Kanalizace_Dešťová 2
963829 | 5.NP | TR.81 | 5.NP | 8684.1 | Kanalizace_Dešťová 2
963880 | 5.NP | TR.82 | 5.NP | 210.579 | Kanalizace_Dešťová 2
964024 | 5.NP | TR.83 | 5.NP | 232.518 | Kanalizace_Dešťová 2
964310 | 5.NP | TR.84 | 5.NP | 8036.86 | Kanalizace_Dešťová 2
964319 | 5.NP mezipatro | TR.85 | 5.NP mezipatro | 1287.93 | Kanalizace_Dešťová 2
964537 | 5.NP | TR.86 | 5.NP | 8604.49 | Kanalizace_Dešťová 2
966281 | 5.NP mezipatro | TR.87 | 5.NP mezipatro | 1277.73 | Kanalizace_Dešťová 2
967064 | 5.NP | TR.88 | 5.NP | 291.062 | Kanalizace_Dešťová 1
967171 | 5.NP | TR.89 | 5.NP | 3564.53 | Kanalizace_Dešťová 1
967546 | 4.NP mezipatro | TR.90 | 4.NP mezipatro | 2666.83 | Kanalizace_Dešťová 1
968748 | 4.NP mezipatro | TR.91 | 4.NP mezipatro | 8036.55 | Kanalizace_Dešťová 1
968845 | 5.NP | TR.92 | 5.NP | 1374.91 | Kanalizace_Dešťová 1
969264 | 5.NP mezipatro | TR.93 | 5.NP mezipatro | 3704.8 | Kanalizace_Dešťová 2
969976 | 4.NP mezipatro | TR.94 | 4.NP mezipatro | 168.349 | Kanalizace_Dešťová 1
970677 | 1.S | TR.95 | 1.S | 9443.34 | Kanalizace_Dešťová 2
970734 | 1.S | TR.96 | 1.S | 1274.98 | Kanalizace_Dešťová 2
970798 | 1.S | TR.97 | 1.S | 11578.7 | Kanalizace_Dešťová 2
970867 | 4.NP mezipatro | TR.98 | 4.NP mezipatro | 166.58 | Kanalizace_Dešťová 2
971312 | 4.NP mezipatro | TR.99 | 4.NP mezipatro | 9601.73 | Kanalizace_Dešťová 2
971382 | 4.NP mezipatro | TR.100 | 4.NP mezipatro | 241.28 | Kanalizace_Dešťová 2
971478 | 5.NP mezipatro | TR.101 | 5.NP mezipatro | 15322.1 | Kanalizace_Dešťová 2
971603 | 4.NP mezipatro | TR.102 | 4.NP mezipatro | 226.422 | Kanalizace_Dešťová 2
971611 | 4.NP mezipatro | TR.103 | 4.NP mezipatro | 9534 | Kanalizace_Dešťová 2
971791 | 4.NP mezipatro | TR.104 | 4.NP mezipatro | 2751.99 | Kanalizace_Dešťová 2
971808 | 4.NP mezipatro | TR.105 | 4.NP mezipatro | 377.491 | Kanalizace_Dešťová 2
972003 | 5.NP mezipatro | TR.106 | 5.NP mezipatro | 14380 | Kanalizace_Dešťová 2
972455 | 1.S | TR.107 | 1.S | 97.7527 | Kanalizace_Splašková 1
972838 | 5.NP mezipatro | TR.108 | 5.NP mezipatro | 11557.7 | Kanalizace_Dešťová 1
973569 | 1.S | TR.109 | 1.S | 125.056 | Kanalizace_Splašková 1
973603 | 1.S | TR.110 | 1.S | 62.5591 | Kanalizace_Splašková 1
973645 | 1.S | TR.111 | 1.S | 1668.51 | Kanalizace_Splašková 1
973718 | 1.S | TR.112 | 1.S | 213.437 | Kanalizace_Splašková 1
974060 | 1.S | TR.113 | 1.S | 2137.06 | Kanalizace_Dešťová 2
974174 | 1.S | TR.114 | 1.S | 1012.07 | Kanalizace_Dešťová 2
974634 | 5.NP mezipatro | TR.115 | 5.NP mezipatro | 429.504 | Kanalizace_Dešťová 2
975026 | 1.S | TR.116 | 1.S | 110.029 | Kanalizace_Dešťová 2
975077 | 1.S | TR.117 | 1.S | 349.956 | Kanalizace_Dešťová 2
975135 | 5.NP mezipatro | TR.118 | 5.NP mezipatro | 591.436 | Kanalizace_Dešťová 1
