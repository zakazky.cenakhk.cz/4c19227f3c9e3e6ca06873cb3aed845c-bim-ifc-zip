Properties of the parts of a building model (IFC4), part 2 of 2

# IfcPipeSegment: Typy trubek:Plast - HT (101)
Name (Typy trubek:Plast - HT:...) | In | Reference | StoreyProjectSpecificIdentifier | Length (mm) | Group
975150 | 5.NP mezipatro | TR.119 | 5.NP mezipatro | 2339 | Kanalizace_Dešťová 1
975255 | 5.NP mezipatro | TR.120 | 5.NP mezipatro | 1143.57 | Kanalizace_Dešťová 1
975423 | 5.NP mezipatro | TR.121 | 5.NP mezipatro | 20398.1 | Kanalizace_Dešťová 1
978030 | 1.S | TR.122 | 1.S | 429.89 | Kanalizace_Dešťová 2
978068 | 1.S | TR.123 | 1.S | 3574.79 | Kanalizace_Dešťová 2
978367 | 1.S | TR.124 | 1.S | 520.971 | Kanalizace_Dešťová 1
980800 | 5.NP mezipatro | TR.127 | 5.NP mezipatro | 335.034 | Kanalizace_Splašková 1
980815 | 1.S | TR.128 | 1.S | 15530.6 | Kanalizace_Splašková 1
980928 | 1.S | TR.129 | 1.S | 1910.94 | Kanalizace_Splašková 1
980944 | 5.NP mezipatro | TR.130 | 5.NP mezipatro | 880.908 | Kanalizace_Splašková 1
980966 | 5.NP mezipatro | TR.131 | 5.NP mezipatro | 1648.5 | Kanalizace_Splašková 1
981922 | 5.NP mezipatro | TR.132 | 5.NP mezipatro | 759.979 | Kanalizace_Splašková 2

# IfcPipeSegment: Typy trubek:Plast - KG (15)
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Trubka
Pset_EnvironmentalImpactIndicators - Reference: Plast - KG; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Plast - KG; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: potrubí KAN; DT_code: KAN.RO.P
Group: Kanalizace_Splašková 1
Name (Typy trubek:Plast - KG:...) | In | Reference | StoreyProjectSpecificIdentifier | Length (mm)
926116 | 1.S | TR.133 | 1.S | 109.694
939098 | 1.S | TR.134 | 1.S | 14901
939125 | 1.S | TR.135 | 1.S | 245.813
939726 | 1.S | TR.136 | 1.S | 2489.34
939787 | 1.S | TR.137 | 1.S | 110.609
939801 | 1.S | TR.138 | 1.S | 845.792
939816 | 1.S | TR.139 | 1.S | 314.242
939903 | 1.S | TR.140 | 1.S | 1241.9
957810 | 1.S mezipatro | TR.141 | 1.S mezipatro | 2195.74
957867 | 1.S | TR.142 | 1.S | 5288.98
957888 | 1.S | TR.143 | 1.S | 167.416
957889 | 1.S | TR.144 | 1.S | 37.9464
957893 | 1.S | TR.145 | 1.S | 729.515
957916 | 1.S | TR.146 | 1.S | 250
973872 | 1.S | TR.147 | 1.S | 250

# IfcValve: Kalich pro úkapy:Kalich pro úkapy (2)
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ARM; ElementProjectSpecificDescription: Kalich pro úkapy
Pset_EnvironmentalImpactIndicators - Reference: Kalich pro úkapy; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: QMA
CZ_ElementCommon - ElementProjectSpecificName: Kalich pro úkapy; ElementProjectObjectIdentifier: SO 01
CZ_DTcommon - DT_name: armatury a ventily KAN; DT_code: KAN.PP.A
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (Kalich pro úkapy:Kalich pro úkapy:...) | In | Reference | StoreyProjectSpecificIdentifier | Group
933575 | 1.S | ARM.26 | 1.S | Kanalizace_Splašková 1
981075 | Střecha | ARM.27 | Střecha | Kanalizace_Splašková 2

# IfcValve: Odvětrávací hlavice.CC:DN 110, Odvětrávací hlavice.CC:DN 110:936814
In: Střecha
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ARM; ElementProjectSpecificDescription: Hlavice
Pset_EnvironmentalImpactIndicators - Reference: DN 110; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: QMA
CZ_ElementCommon - ElementProjectSpecificName: DN 110; ElementProjectObjectIdentifier: SO 01; Reference: ARM.25; StoreyProjectSpecificIdentifier: Střecha
CZ_DTcommon - DT_name: armatury a ventily KAN; DT_code: KAN.PP.A
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Splašková 1

# IfcValve: Přivzdušňovací ventil.CC:DN 75, Přivzdušňovací ventil.CC:DN 75:938543
In: 1.S
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ARM; ElementProjectSpecificDescription: Ventil
Pset_EnvironmentalImpactIndicators - Reference: DN 75; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: QMA
CZ_ElementCommon - ElementProjectSpecificName: DN 75; ElementProjectObjectIdentifier: SO 01; Reference: ARM.24; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: armatury a ventily KAN; DT_code: KAN.PP.A
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Splašková 1

# IfcValve: Revizní šachta.CC:DN125 (2)
In: 1.S
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: RŠ; ElementProjectSpecificDescription: Revizní šachta
Pset_EnvironmentalImpactIndicators - Reference: DN125; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: QMA
CZ_ElementCommon - ElementProjectSpecificName: DN125; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: armatury a ventily KAN; DT_code: KAN.PP.A
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (Revizní šachta.CC:DN125:...) | Reference
948169 | RŠ.22
952099 | RŠ.23

# IfcValve: Sifon.CC:Sifon_Umyvadlo (2)
In: 1.S
Type - Material: NEREZOVÁ OCEL
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ZU; ElementProjectSpecificDescription: Sifon.CC, Sifon_Umyvadlo
Pset_EnvironmentalImpactIndicators - Reference: Sifon_Umyvadlo; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: G; CCI_TechnicalSystemsCode: JD; CCI_ComponentsCode: QMA
CZ_ElementCommon - ElementProjectSpecificName: Sifon_Umyvadlo; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: armatury a ventily KAN; DT_code: KAN.PP.A
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Kanalizace_Splašková 1
Name (Sifon.CC:Sifon_Umyvadlo:...) | Reference
904547 | ZU.28
918702 | ZU.29
