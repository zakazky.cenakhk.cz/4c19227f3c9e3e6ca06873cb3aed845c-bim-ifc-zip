Properties of the parts of a building model (IFC4), part 4 of 7

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CXKH-V-J 3x1,5 (724)
Name (Elektroinstalační trubka bez tvarovek:CXKH-V-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
72168 | 2.NP mezipatro | K04.72168 | 2.NP mezipatro | 1273.19 | RPO-N0.02
72170 | 3.NP | K04.72170 | 3.NP | 1273.19 | RPO-N0.02
72172 | 3.NP mezipatro | K04.72172 | 3.NP mezipatro | 1273.19 | RPO-N0.02
72174 | 4.NP | K04.72174 | 4.NP | 1273.19 | RPO-N0.02
72176 | 4.NP mezipatro | K04.72176 | 4.NP mezipatro | 1273.19 | RPO-N0.02
72239 | 5.NP mezipatro | K04.72239 | 5.NP mezipatro | 2295.24 | RPO-N0.02
72289 | 1.NP | K04.72289 | 1.NP | 450.3 | RPO-N0.02
72314 | 1.NP | K04.72314 | 1.NP | 1440 | RPO-N0.02
72319 | 1.S mezipatro | K04.72319 | 1.S mezipatro | 199.7 | RPO-N0.02
72324 | 1.S mezipatro | K04.72324 | 1.S mezipatro | 1485 | RPO-N0.02
72330 | 1.NP mezipatro | K04.72330 | 1.NP mezipatro | 199.7 | RPO-N0.02
72335 | 1.NP mezipatro | K04.72335 | 1.NP mezipatro | 1440 | RPO-N0.02
72340 | 2.NP | K04.72340 | 2.NP | 435.3 | RPO-N0.02
72345 | 2.NP | K04.72345 | 2.NP | 1440 | RPO-N0.02
72350 | 2.NP mezipatro | K04.72350 | 2.NP mezipatro | 184.7 | RPO-N0.02
72356 | 2.NP mezipatro | K04.72356 | 2.NP mezipatro | 1440 | RPO-N0.02
72361 | 3.NP | K04.72361 | 3.NP | 435.3 | RPO-N0.02
72366 | 3.NP | K04.72366 | 3.NP | 1440 | RPO-N0.02
72371 | 3.NP mezipatro | K04.72371 | 3.NP mezipatro | 184.7 | RPO-N0.02
72376 | 3.NP mezipatro | K04.72376 | 3.NP mezipatro | 1440 | RPO-N0.02
72384 | 4.NP | K04.72384 | 4.NP | 435.3 | RPO-N0.02
72403 | 4.NP | K04.72403 | 4.NP | 1440 | RPO-N0.02
72423 | 4.NP mezipatro | K04.72423 | 4.NP mezipatro | 184.7 | RPO-N0.02
72442 | 4.NP mezipatro | K04.72442 | 4.NP mezipatro | 1440 | RPO-N0.02
72631 | 5.NP mezipatro | K04.72631 | 5.NP mezipatro | 1293.19 | RPO-N0.02
72640 | 5.NP mezipatro | K04.72640 | 5.NP mezipatro | 1074.88 | RPO-N0.02
72653 | 5.NP mezipatro | K04.72653 | 5.NP mezipatro | 412.51 | RPO-N0.02
72729 | 1.S | K04.72729 | 1.S | 5437.99 | RPO-N0.03
72742 | 1.S | K04.72742 | 1.S | 2285 | RPO-N0.03
72763 | 1.S | K04.72763 | 1.S | 534.024 | RPO-N0.03
72780 | 1.S | K04.72780 | 1.S | 884.039 | RPO-N0.03
72839 | 1.S | K04.72839 | 1.S | 93.13 | RPO-N0.03
72908 | 1.S | K04.72908 | 1.S | 555.943 | RPO-N0.03
72936 | 1.S | K04.72936 | 1.S | 962.6 | RPO-N0.03
72953 | 1.S | K04.72953 | 1.S | 140.72 | RPO-N0.03
72954 | 1.S | K04.72954 | 1.S | 241.42 | RPO-N0.03
72970 | 1.S | K04.72970 | 1.S | 520.76 | RPO-N0.03
72979 | 1.S | K04.72979 | 1.S | 120 | RPO-N0.03
72982 | 1.S | K04.72982 | 1.S | 6428 | RPO-N0.03
72994 | 1.S | K04.72994 | 1.S | 520.76 | RPO-N0.03
73003 | 1.S | K04.73003 | 1.S | 120 | RPO-N0.03
73006 | 1.S | K04.73006 | 1.S | 5378.29 | RPO-N0.03
73018 | 1.S | K04.73018 | 1.S | 520.76 | RPO-N0.03
73027 | 1.S | K04.73027 | 1.S | 120 | RPO-N0.03
73030 | 1.S | K04.73030 | 1.S | 5079.27 | RPO-N0.03
73035 | 1.S | K04.73035 | 1.S | 520.76 | RPO-N0.03
73044 | 1.S | K04.73044 | 1.S | 120 | RPO-N0.03
73047 | 1.S | K04.73047 | 1.S | 5312.43 | RPO-N0.03
73052 | 1.S | K04.73052 | 1.S | 520.76 | RPO-N0.03
73061 | 1.S | K04.73061 | 1.S | 120 | RPO-N0.03
73064 | 1.S | K04.73064 | 1.S | 3190 | RPO-N0.03
73078 | 1.S | K04.73078 | 1.S | 105 | RPO-N0.03
73081 | 1.S | K04.73081 | 1.S | 4754.91 | RPO-N0.03
73135 | 1.S | K04.73135 | 1.S | 4080.37 | RPO-N0.03
73165 | 1.S | K04.73165 | 1.S | 2861.02 | RPO-N0.03
73194 | 1.S | K04.73194 | 1.S | 1453.02 | RPO-N0.03
73220 | 1.S | K04.73220 | 1.S | 1118.28 | RPO-N0.03
73259 | 1.S | K04.73259 | 1.S | 198.64 | RPO-N0.03
73267 | 1.S | K04.73267 | 1.S | 373.63 | RPO-N0.03
73478 | 1.S | K04.73478 | 1.S | 355.51 | RPO-N0.03
73485 | 1.S | K04.73485 | 1.S | 105 | RPO-N0.03
73488 | 1.S | K04.73488 | 1.S | 318.29 | RPO-N0.03
73495 | 1.S | K04.73495 | 1.S | 603.16 | RPO-N0.03
73512 | 1.S | K04.73512 | 1.S | 115.958 | RPO-N0.03
73513 | 1.S | K04.73513 | 1.S | 220.21 | RPO-N0.03
73642 | 1.S | K04.73642 | 1.S | 6675.69 | RPO-N0.03
73735 | 1.S | K04.73735 | 1.S | 4875 | RPO-N0.03
73781 | 1.S | K04.73781 | 1.S | 261.29 | RPO-N0.03
73813 | 1.S | K04.73813 | 1.S | 1349.65 | RPO-N0.03
73835 | 1.S | K04.73835 | 1.S | 1285 | RPO-N0.03
73888 | 1.S | K04.73888 | 1.S | 85 | RPO-N0.03
73891 | 1.S | K04.73891 | 1.S | 4129.99 | RPO-N0.03
73941 | 1.S | K04.73941 | 1.S | 85 | RPO-N0.03
73944 | 1.S | K04.73944 | 1.S | 2439.4 | RPO-N0.03
73953 | 1.S | K04.73953 | 1.S | 85 | RPO-N0.03
73956 | 1.S | K04.73956 | 1.S | 2399.16 | RPO-N0.03
74247 | 1.S | K04.74247 | 1.S | 957.36 | RPO-N0.03
75129 | 1.S | K04.75129 | 1.S | 594.37 | RPO-N0.04
75132 | 1.S | K04.75132 | 1.S | 867.87 | RPO-N0.04
75140 | 1.S | K04.75140 | 1.S | 165.063 | RPO-N0.04
75154 | 1.S | K04.75154 | 1.S | 1153.03 | RPO-N0.04
75157 | 1.S | K04.75157 | 1.S | 85 | RPO-N0.04
75160 | 1.S | K04.75160 | 1.S | 2250.01 | RPO-N0.04
75173 | 1.S | K04.75173 | 1.S | 864.046 | RPO-N0.04
75176 | 1.S | K04.75176 | 1.S | 85 | RPO-N0.04
75179 | 1.S | K04.75179 | 1.S | 2042.16 | RPO-N0.04
75184 | 1.S | K04.75184 | 1.S | 1458.36 | RPO-N0.04
75187 | 1.S | K04.75187 | 1.S | 85 | RPO-N0.04
75190 | 1.S | K04.75190 | 1.S | 3217.11 | RPO-N0.04
75195 | 1.S | K04.75195 | 1.S | 5779.53 | RPO-N0.04
75198 | 1.S | K04.75198 | 1.S | 85 | RPO-N0.04
75201 | 1.S | K04.75201 | 1.S | 4386.42 | RPO-N0.04
75206 | 1.S | K04.75206 | 1.S | 1850.84 | RPO-N0.04
75210 | 1.S | K04.75210 | 1.S | 620.14 | RPO-N0.04
75213 | 1.S | K04.75213 | 1.S | 85 | RPO-N0.04
75216 | 1.S | K04.75216 | 1.S | 1113.91 | RPO-N0.04
75221 | 1.S | K04.75221 | 1.S | 327 | RPO-N0.04
75228 | 1.S | K04.75228 | 1.S | 332.72 | RPO-N0.04
75234 | 1.S | K04.75234 | 1.S | 350 | RPO-N0.04
75237 | 1.S | K04.75237 | 1.S | 1285 | RPO-N0.04
75243 | 1.S | K04.75243 | 1.S | 65 | RPO-N0.04
75246 | 1.S | K04.75246 | 1.S | 153.34 | RPO-N0.04
75272 | 1.S | K04.75272 | 1.S | 152.21 | RPO-N0.04
75275 | 1.S | K04.75275 | 1.S | 550.19 | RPO-N0.04
75279 | 1.S | K04.75279 | 1.S | 319.29 | RPO-N0.04
76198 | 1.S | K04.76198 | 1.S | 35845.9 | RPO-N0.05
76199 | 1.S | K04.76199 | 1.S | 4429.57 | RPO-N0.05
76202 | 1.S | K04.76202 | 1.S | 6018.6 | RPO-N0.05
76205 | 1.S | K04.76205 | 1.S | 3179.41 | RPO-N0.05
76208 | 1.S | K04.76208 | 1.S | 264.004 | RPO-N0.05
76212 | 1.S | K04.76212 | 1.S | 1285 | RPO-N0.05
76234 | 1.S | K04.76234 | 1.S | 1395.11 | RPO-N0.05
76237 | 1.S | K04.76237 | 1.S | 85 | RPO-N0.05
76240 | 1.S | K04.76240 | 1.S | 1689.86 | RPO-N0.05
76250 | 5.NP | K04.76250 | 5.NP | 2920 | RPO-N0.05
76255 | 1.S | K04.76255 | 1.S | 255.66 | RPO-N0.05
76260 | 1.NP | K04.76260 | 1.NP | 3734.52 | RPO-N0.05
76264 | 1.NP | K04.76264 | 1.NP | 266.66 | RPO-N0.05
76269 | 2.NP | K04.76269 | 2.NP | 3734.52 | RPO-N0.05
76270 | 2.NP | K04.76270 | 2.NP | 266.66 | RPO-N0.05
76276 | 3.NP | K04.76276 | 3.NP | 3734.52 | RPO-N0.05
76277 | 3.NP | K04.76277 | 3.NP | 266.66 | RPO-N0.05
76283 | 4.NP | K04.76283 | 4.NP | 3734.52 | RPO-N0.05
76284 | 4.NP | K04.76284 | 4.NP | 266.66 | RPO-N0.05
76290 | 5.NP | K04.76290 | 5.NP | 3714.52 | RPO-N0.05
76291 | 5.NP | K04.76291 | 5.NP | 266.66 | RPO-N0.05
76297 | 1.S | K04.76297 | 1.S | 3292.72 | RPO-N0.05
76300 | 1.S mezipatro | K04.76300 | 1.S mezipatro | 1400 | RPO-N0.05
76305 | 1.S mezipatro | K04.76305 | 1.S mezipatro | 2743.24 | RPO-N0.05
76314 | 1.S | K04.76314 | 1.S | 789.35 | RPO-N0.05
76318 | 1.S mezipatro | K04.76318 | 1.S mezipatro | 1650.65 | RPO-N0.05
76324 | 5.NP mezipatro | K04.76324 | 5.NP mezipatro | 2920 | RPO-N0.05
76329 | 1.S mezipatro | K04.76329 | 1.S mezipatro | 286.66 | RPO-N0.05
76332 | 1.S mezipatro | K04.76332 | 1.S mezipatro | 789.35 | RPO-N0.05
76336 | 1.NP mezipatro | K04.76336 | 1.NP mezipatro | 266.66 | RPO-N0.05
76337 | 1.NP mezipatro | K04.76337 | 1.NP mezipatro | 1650.65 | RPO-N0.05
76342 | 1.NP mezipatro | K04.76342 | 1.NP mezipatro | 2920 | RPO-N0.05
76348 | 2.NP mezipatro | K04.76348 | 2.NP mezipatro | 266.66 | RPO-N0.05
76349 | 2.NP mezipatro | K04.76349 | 2.NP mezipatro | 1650.65 | RPO-N0.05
76355 | 3.NP mezipatro | K04.76355 | 3.NP mezipatro | 266.66 | RPO-N0.05
76356 | 3.NP mezipatro | K04.76356 | 3.NP mezipatro | 1650.65 | RPO-N0.05
76362 | 4.NP mezipatro | K04.76362 | 4.NP mezipatro | 266.76 | RPO-N0.05
76363 | 4.NP mezipatro | K04.76363 | 4.NP mezipatro | 1650.65 | RPO-N0.05
76369 | 5.NP mezipatro | K04.76369 | 5.NP mezipatro | 266.76 | RPO-N0.05
76370 | 5.NP mezipatro | K04.76370 | 5.NP mezipatro | 1630.65 | RPO-N0.05
76381 | 4.NP mezipatro | K04.76381 | 4.NP mezipatro | 2940.1 | RPO-N0.05
76388 | 3.NP mezipatro | K04.76388 | 3.NP mezipatro | 2940 | RPO-N0.05
76395 | 2.NP mezipatro | K04.76395 | 2.NP mezipatro | 2940 | RPO-N0.05
76407 | 4.NP | K04.76407 | 4.NP | 2940 | RPO-N0.05
76415 | 3.NP | K04.76415 | 3.NP | 2940 | RPO-N0.05
76423 | 2.NP | K04.76423 | 2.NP | 2940 | RPO-N0.05
76431 | 1.S | K04.76431 | 1.S | 2920 | RPO-N0.05
76999 | 1.S | K04.76999 | 1.S | 192.66 | RPO-N0.06
77009 | 1.NP | K04.77009 | 1.NP | 759.7 | RPO-N0.06
77010 | 1.NP | K04.77010 | 1.NP | 266.66 | RPO-N0.06
77011 | 2.NP | K04.77011 | 2.NP | 759.7 | RPO-N0.06
77012 | 2.NP | K04.77012 | 2.NP | 266.66 | RPO-N0.06
77013 | 3.NP | K04.77013 | 3.NP | 759.7 | RPO-N0.06
77014 | 3.NP | K04.77014 | 3.NP | 266.66 | RPO-N0.06
77015 | 4.NP | K04.77015 | 4.NP | 759.7 | RPO-N0.06
77016 | 4.NP | K04.77016 | 4.NP | 266.66 | RPO-N0.06
77017 | 5.NP mezipatro | K04.77017 | 5.NP mezipatro | 774.7 | RPO-N0.06
77018 | 5.NP | K04.77018 | 5.NP | 2465.66 | RPO-N0.06
77029 | 1.S | K04.77029 | 1.S | 2003.14 | RPO-N0.06
77038 | 1.S mezipatro | K04.77038 | 1.S mezipatro | 285.71 | RPO-N0.06
77040 | 1.S mezipatro | K04.77040 | 1.S mezipatro | 810.59 | RPO-N0.06
77043 | 1.NP mezipatro | K04.77043 | 1.NP mezipatro | 266.66 | RPO-N0.06
77044 | 1.NP mezipatro | K04.77044 | 1.NP mezipatro | 810.59 | RPO-N0.06
77050 | 2.NP mezipatro | K04.77050 | 2.NP mezipatro | 266.66 | RPO-N0.06
77051 | 2.NP mezipatro | K04.77051 | 2.NP mezipatro | 810.59 | RPO-N0.06
77052 | 3.NP mezipatro | K04.77052 | 3.NP mezipatro | 266.66 | RPO-N0.06
77053 | 3.NP mezipatro | K04.77053 | 3.NP mezipatro | 810.59 | RPO-N0.06
77054 | 4.NP mezipatro | K04.77054 | 4.NP mezipatro | 266.66 | RPO-N0.06
77055 | 4.NP mezipatro | K04.77055 | 4.NP mezipatro | 810.59 | RPO-N0.06
77056 | 5.NP mezipatro | K04.77056 | 5.NP mezipatro | 855.66 | RPO-N0.06
77057 | 5.NP mezipatro | K04.77057 | 5.NP mezipatro | 825.59 | RPO-N0.06
77162 | 1.S mezipatro | K04.77162 | 1.S mezipatro | 1909.7 | RPO-N0.06
77166 | 1.NP | K04.77166 | 1.NP | 3340.4 | RPO-N0.06
77170 | 1.NP mezipatro | K04.77170 | 1.NP mezipatro | 1909.7 | RPO-N0.06
77172 | 2.NP | K04.77172 | 2.NP | 3340.4 | RPO-N0.06
77174 | 2.NP mezipatro | K04.77174 | 2.NP mezipatro | 1912.2 | RPO-N0.06
77176 | 3.NP | K04.77176 | 3.NP | 3340.4 | RPO-N0.06
77178 | 3.NP mezipatro | K04.77178 | 3.NP mezipatro | 1909.7 | RPO-N0.06
77180 | 4.NP | K04.77180 | 4.NP | 3340.4 | RPO-N0.06
77182 | 4.NP mezipatro | K04.77182 | 4.NP mezipatro | 1912.2 | RPO-N0.06
77203 | 1.S | K04.77203 | 1.S | 3436.23 | RPO-N0.06
77204 | 1.S | K04.77204 | 1.S | 1133.55 | RPO-N0.06
77205 | 1.S mezipatro | K04.77205 | 1.S mezipatro | 1258.19 | RPO-N0.06
77207 | 5.NP | K04.77207 | 5.NP | 3620 | RPO-N0.06
77210 | 1.NP | K04.77210 | 1.NP | 1258.19 | RPO-N0.06
77211 | 1.NP mezipatro | K04.77211 | 1.NP mezipatro | 1258.19 | RPO-N0.06
77212 | 2.NP | K04.77212 | 2.NP | 1258.19 | RPO-N0.06
77213 | 2.NP mezipatro | K04.77213 | 2.NP mezipatro | 1258.19 | RPO-N0.06
77214 | 3.NP | K04.77214 | 3.NP | 1258.19 | RPO-N0.06
77215 | 3.NP mezipatro | K04.77215 | 3.NP mezipatro | 1258.19 | RPO-N0.06
77216 | 4.NP | K04.77216 | 4.NP | 1258.19 | RPO-N0.06
77217 | 4.NP mezipatro | K04.77217 | 4.NP mezipatro | 1258.19 | RPO-N0.06
77238 | 5.NP mezipatro | K04.77238 | 5.NP mezipatro | 3379.43 | RPO-N0.06
77239 | 1.S | K04.77239 | 1.S | 339.46 | RPO-N0.06
77242 | 1.S | K04.77242 | 1.S | 573.79 | RPO-N0.06
77243 | 1.S | K04.77243 | 1.S | 13463.1 | RPO-N0.06
77266 | 1.NP | K04.77266 | 1.NP | 435.3 | RPO-N0.06
77270 | 1.NP | K04.77270 | 1.NP | 1440 | RPO-N0.06
77273 | 1.S mezipatro | K04.77273 | 1.S mezipatro | 184.7 | RPO-N0.06
77275 | 1.S mezipatro | K04.77275 | 1.S mezipatro | 1485 | RPO-N0.06
77280 | 1.NP mezipatro | K04.77280 | 1.NP mezipatro | 184.7 | RPO-N0.06
77282 | 1.NP mezipatro | K04.77282 | 1.NP mezipatro | 1440 | RPO-N0.06
77286 | 2.NP | K04.77286 | 2.NP | 435.3 | RPO-N0.06
77288 | 2.NP | K04.77288 | 2.NP | 1440 | RPO-N0.06
77292 | 2.NP mezipatro | K04.77292 | 2.NP mezipatro | 184.7 | RPO-N0.06
77295 | 2.NP mezipatro | K04.77295 | 2.NP mezipatro | 1440 | RPO-N0.06
77299 | 3.NP | K04.77299 | 3.NP | 435.3 | RPO-N0.06
77301 | 3.NP | K04.77301 | 3.NP | 1440 | RPO-N0.06
77305 | 3.NP mezipatro | K04.77305 | 3.NP mezipatro | 184.7 | RPO-N0.06
77307 | 3.NP mezipatro | K04.77307 | 3.NP mezipatro | 1440 | RPO-N0.06
77311 | 4.NP | K04.77311 | 4.NP | 435.3 | RPO-N0.06
77313 | 4.NP | K04.77313 | 4.NP | 1440 | RPO-N0.06
77317 | 4.NP mezipatro | K04.77317 | 4.NP mezipatro | 184.7 | RPO-N0.06
77319 | 4.NP mezipatro | K04.77319 | 4.NP mezipatro | 1440 | RPO-N0.06
77328 | 5.NP mezipatro | K04.77328 | 5.NP mezipatro | 1263.19 | RPO-N0.06
77330 | 5.NP mezipatro | K04.77330 | 5.NP mezipatro | 2691.91 | RPO-N0.06
77332 | 5.NP mezipatro | K04.77332 | 5.NP mezipatro | 397.51 | RPO-N0.06
78277 | 1.S mezipatro | K04.78277 | 1.S mezipatro | 53.83 | RPO-N0.11
78285 | 1.S mezipatro | K04.78285 | 1.S mezipatro | 1368.32 | RPO-N0.11
78309 | 1.S mezipatro | K04.78309 | 1.S mezipatro | 1616.17 | RPO-N0.11
78317 | 1.S mezipatro | K04.78317 | 1.S mezipatro | 3340.25 | RPO-N0.11
78333 | 1.S mezipatro | K04.78333 | 1.S mezipatro | 170.71 | RPO-N0.11
78351 | 1.S mezipatro | K04.78351 | 1.S mezipatro | 1616.17 | RPO-N0.11
78362 | 1.S mezipatro | K04.78362 | 1.S mezipatro | 70 | RPO-N0.11
78365 | 1.S mezipatro | K04.78365 | 1.S mezipatro | 3185 | RPO-N0.11
78373 | 1.S mezipatro | K04.78373 | 1.S mezipatro | 1616.17 | RPO-N0.11
78382 | 1.S mezipatro | K04.78382 | 1.S mezipatro | 70 | RPO-N0.11
78385 | 1.S mezipatro | K04.78385 | 1.S mezipatro | 5375.08 | RPO-N0.11
78393 | 1.S mezipatro | K04.78393 | 1.S mezipatro | 1616.17 | RPO-N0.11
78402 | 1.S mezipatro | K04.78402 | 1.S mezipatro | 70 | RPO-N0.11
78405 | 1.S mezipatro | K04.78405 | 1.S mezipatro | 5082.48 | RPO-N0.11
78413 | 1.S mezipatro | K04.78413 | 1.S mezipatro | 1616.17 | RPO-N0.11
78422 | 1.S mezipatro | K04.78422 | 1.S mezipatro | 70 | RPO-N0.11
78425 | 1.S mezipatro | K04.78425 | 1.S mezipatro | 5312.43 | RPO-N0.11
78433 | 1.S mezipatro | K04.78433 | 1.S mezipatro | 1616.17 | RPO-N0.11
78442 | 1.S mezipatro | K04.78442 | 1.S mezipatro | 70 | RPO-N0.11
78445 | 1.S mezipatro | K04.78445 | 1.S mezipatro | 6340 | RPO-N0.11
78453 | 1.S mezipatro | K04.78453 | 1.S mezipatro | 1750 | RPO-N0.11
78461 | 1.S mezipatro | K04.78461 | 1.S mezipatro | 2548.49 | RPO-N0.11
78471 | 1.S mezipatro | K04.78471 | 1.S mezipatro | 70 | RPO-N0.11
78474 | 1.S mezipatro | K04.78474 | 1.S mezipatro | 2126.17 | RPO-N0.11
78489 | 1.S mezipatro | K04.78489 | 1.S mezipatro | 2688.54 | RPO-N0.11
78496 | 1.S mezipatro | K04.78496 | 1.S mezipatro | 70 | RPO-N0.11
78499 | 1.S mezipatro | K04.78499 | 1.S mezipatro | 4184.7 | RPO-N0.11
78504 | 1.S mezipatro | K04.78504 | 1.S mezipatro | 2862.41 | RPO-N0.11
78513 | 1.S mezipatro | K04.78513 | 1.S mezipatro | 70 | RPO-N0.11
78516 | 1.S mezipatro | K04.78516 | 1.S mezipatro | 3195 | RPO-N0.11
78542 | 1.S mezipatro | K04.78542 | 1.S mezipatro | 5004.86 | RPO-N0.11
78629 | 1.S | K04.78629 | 1.S | 1514.58 | RPO-N0.11
78680 | 1.S mezipatro | K04.78680 | 1.S mezipatro | 1415 | RPO-N0.11
78760 | 1.S | K04.78760 | 1.S | 449.79 | RPO-N0.11
78761 | 1.S | K04.78761 | 1.S | 12596.8 | RPO-N0.11
78762 | 1.S | K04.78762 | 1.S | 3059.41 | RPO-N0.11
78765 | 1.S | K04.78765 | 1.S | 279.004 | RPO-N0.11
78768 | 1.S | K04.78768 | 1.S | 1285 | RPO-N0.11
99408 | 1.S | K04.99408 | 1.S | 303.11 | RPO-N1.01
99410 | 1.S | K04.99410 | 1.S | 14561.2 | RPO-N1.01
99411 | 1.NP mezipatro | K04.99411 | 1.NP mezipatro | 4395 | RPO-N1.01
99412 | 1.S | K04.99412 | 1.S | 1005 | RPO-N1.01
99419 | 1.NP mezipatro | K04.99419 | 1.NP mezipatro | 6680.03 | RPO-N1.01
99429 | 1.NP mezipatro | K04.99429 | 1.NP mezipatro | 1404.73 | RPO-N1.01
99439 | 1.NP mezipatro | K04.99439 | 1.NP mezipatro | 3182.85 | RPO-N1.01
99444 | 1.NP mezipatro | K04.99444 | 1.NP mezipatro | 3205.41 | RPO-N1.01
99447 | 1.NP mezipatro | K04.99447 | 1.NP mezipatro | 1454.73 | RPO-N1.01
99449 | 1.NP mezipatro | K04.99449 | 1.NP mezipatro | 70 | RPO-N1.01
99451 | 1.NP mezipatro | K04.99451 | 1.NP mezipatro | 5381.51 | RPO-N1.01
99455 | 1.NP mezipatro | K04.99455 | 1.NP mezipatro | 1467.95 | RPO-N1.01
99457 | 1.NP mezipatro | K04.99457 | 1.NP mezipatro | 1467.95 | RPO-N1.01
99459 | 1.NP mezipatro | K04.99459 | 1.NP mezipatro | 1467.95 | RPO-N1.01
99461 | 1.NP mezipatro | K04.99461 | 1.NP mezipatro | 1467.95 | RPO-N1.01
99463 | 1.NP mezipatro | K04.99463 | 1.NP mezipatro | 1404.73 | RPO-N1.01
99464 | 1.NP mezipatro | K04.99464 | 1.NP mezipatro | 3207.68 | RPO-N1.01
99466 | 1.NP mezipatro | K04.99466 | 1.NP mezipatro | 70 | RPO-N1.01
99468 | 1.NP mezipatro | K04.99468 | 1.NP mezipatro | 144.82 | RPO-N1.01
99475 | 1.NP mezipatro | K04.99475 | 1.NP mezipatro | 70 | RPO-N1.01
99477 | 1.NP mezipatro | K04.99477 | 1.NP mezipatro | 1374.58 | RPO-N1.01
99481 | 1.NP mezipatro | K04.99481 | 1.NP mezipatro | 70 | RPO-N1.01
99483 | 1.NP mezipatro | K04.99483 | 1.NP mezipatro | 6429.53 | RPO-N1.01
99487 | 1.NP mezipatro | K04.99487 | 1.NP mezipatro | 70 | RPO-N1.01
99489 | 1.NP mezipatro | K04.99489 | 1.NP mezipatro | 5267.22 | RPO-N1.01
99493 | 1.NP mezipatro | K04.99493 | 1.NP mezipatro | 70 | RPO-N1.01
99495 | 1.NP mezipatro | K04.99495 | 1.NP mezipatro | 5124.48 | RPO-N1.01
99624 | 1.NP mezipatro | K04.99624 | 1.NP mezipatro | 2881.62 | RPO-N1.01
99626 | 1.NP mezipatro | K04.99626 | 1.NP mezipatro | 5269.46 | RPO-N1.01
99677 | 1.NP mezipatro | K04.99677 | 1.NP mezipatro | 70 | RPO-N1.01
99680 | 1.NP mezipatro | K04.99680 | 1.NP mezipatro | 3177.8 | RPO-N1.01
102108 | 1.NP mezipatro | K04.102108 | 1.NP mezipatro | 190.72 | RPO-N1.01
102109 | 1.NP mezipatro | K04.102109 | 1.NP mezipatro | 170.71 | RPO-N1.01
102119 | 1.NP | K04.102119 | 1.NP | 530.63 | RPO-N1.11
102122 | 1.NP | K04.102122 | 1.NP | 1564.41 | RPO-N1.11
102125 | 1.NP | K04.102125 | 1.NP | 7951.47 | RPO-N1.11
102130 | 1.NP | K04.102130 | 1.NP | 837.77 | RPO-N1.11
102133 | 1.NP | K04.102133 | 1.NP | 837.77 | RPO-N1.11
102136 | 1.NP | K04.102136 | 1.NP | 837.77 | RPO-N1.11
102139 | 1.NP | K04.102139 | 1.NP | 837.77 | RPO-N1.11
102142 | 1.NP | K04.102142 | 1.NP | 837.77 | RPO-N1.11
102145 | 1.NP | K04.102145 | 1.NP | 837.77 | RPO-N1.11
102159 | 1.NP | K04.102159 | 1.NP | 70 | RPO-N1.11
102162 | 1.NP | K04.102162 | 1.NP | 4696.33 | RPO-N1.11
102167 | 1.NP | K04.102167 | 1.NP | 70 | RPO-N1.11
102170 | 1.NP | K04.102170 | 1.NP | 6534.16 | RPO-N1.11
102175 | 1.NP | K04.102175 | 1.NP | 70 | RPO-N1.11
102178 | 1.NP | K04.102178 | 1.NP | 5259.34 | RPO-N1.11
102183 | 1.NP | K04.102183 | 1.NP | 70 | RPO-N1.11
102186 | 1.NP | K04.102186 | 1.NP | 5134.9 | RPO-N1.11
102191 | 1.NP | K04.102191 | 1.NP | 70 | RPO-N1.11
102194 | 1.NP | K04.102194 | 1.NP | 5250.45 | RPO-N1.11
102199 | 1.NP | K04.102199 | 1.NP | 70 | RPO-N1.11
102202 | 1.NP | K04.102202 | 1.NP | 3192.74 | RPO-N1.11
102207 | 1.NP | K04.102207 | 1.NP | 984.6 | RPO-N1.11
102210 | 1.NP | K04.102210 | 1.NP | 2947.85 | RPO-N1.11
102216 | 1.NP | K04.102216 | 1.NP | 70 | RPO-N1.11
102219 | 1.NP | K04.102219 | 1.NP | 66.83 | RPO-N1.11
102226 | 1.S | K04.102226 | 1.S | 1790.04 | RPO-N1.11
102227 | 1.NP | K04.102227 | 1.NP | 2895 | RPO-N1.11
102230 | 1.S | K04.102230 | 1.S | 301.16 | RPO-N1.11
102231 | 1.S | K04.102231 | 1.S | 12470 | RPO-N1.11
102232 | 1.S | K04.102232 | 1.S | 3053.23 | RPO-N1.11
102235 | 1.S | K04.102235 | 1.S | 298.11 | RPO-N1.11
102238 | 1.S | K04.102238 | 1.S | 1305 | RPO-N1.11
102276 | 1.NP | K04.102276 | 1.NP | 115.72 | RPO-N1.11
102277 | 1.NP | K04.102277 | 1.NP | 170.71 | RPO-N1.11
102288 | 2.NP | K04.102288 | 2.NP | 530.63 | RPO-N2.11
102290 | 2.NP | K04.102290 | 2.NP | 152.75 | RPO-N2.11
102291 | 2.NP | K04.102291 | 2.NP | 7825.3 | RPO-N2.11
102294 | 2.NP | K04.102294 | 2.NP | 1070.77 | RPO-N2.11
102296 | 2.NP | K04.102296 | 2.NP | 1070.77 | RPO-N2.11
102298 | 2.NP | K04.102298 | 2.NP | 1070.77 | RPO-N2.11
102300 | 2.NP | K04.102300 | 2.NP | 1070.77 | RPO-N2.11
102302 | 2.NP | K04.102302 | 2.NP | 1070.77 | RPO-N2.11
102304 | 2.NP | K04.102304 | 2.NP | 1014.66 | RPO-N2.11
102306 | 2.NP | K04.102306 | 2.NP | 70 | RPO-N2.11
102308 | 2.NP | K04.102308 | 2.NP | 4674.18 | RPO-N2.11
102311 | 2.NP | K04.102311 | 2.NP | 70 | RPO-N2.11
102313 | 2.NP | K04.102313 | 2.NP | 6551.75 | RPO-N2.11
102317 | 2.NP | K04.102317 | 2.NP | 70 | RPO-N2.11
102319 | 2.NP | K04.102319 | 2.NP | 5266.55 | RPO-N2.11
102323 | 2.NP | K04.102323 | 2.NP | 70 | RPO-N2.11
102325 | 2.NP | K04.102325 | 2.NP | 5127.7 | RPO-N2.11
102329 | 2.NP | K04.102329 | 2.NP | 70 | RPO-N2.11
102331 | 2.NP | K04.102331 | 2.NP | 5264.01 | RPO-N2.11
102335 | 2.NP | K04.102335 | 2.NP | 70 | RPO-N2.11
102337 | 2.NP | K04.102337 | 2.NP | 1374.96 | RPO-N2.11
102352 | 2.NP | K04.102352 | 2.NP | 5875 | RPO-N2.11
102356 | 2.NP | K04.102356 | 2.NP | 348.72 | RPO-N2.11
102357 | 2.NP | K04.102357 | 2.NP | 170.71 | RPO-N2.11
102395 | 1.S | K04.102395 | 1.S | 14533.2 | RPO-N2.11
102396 | 1.S | K04.102396 | 1.S | 2972.62 | RPO-N2.11
102399 | 1.S | K04.102399 | 1.S | 279.11 | RPO-N2.11
102402 | 1.S | K04.102402 | 1.S | 1325 | RPO-N2.11
102487 | 2.NP | K04.102487 | 2.NP | 3200.04 | RPO-N2.11
103021 | 2.NP mezipatro | K04.103021 | 2.NP mezipatro | 7375 | RPO-N2.01
103022 | 2.NP mezipatro | K04.103022 | 2.NP mezipatro | 6700.03 | RPO-N2.01
103027 | 2.NP mezipatro | K04.103027 | 2.NP mezipatro | 1164.67 | RPO-N2.01
103028 | 2.NP mezipatro | K04.103028 | 2.NP mezipatro | 3590 | RPO-N2.01
103031 | 2.NP mezipatro | K04.103031 | 2.NP mezipatro | 3286.34 | RPO-N2.01
103032 | 2.NP mezipatro | K04.103032 | 2.NP mezipatro | 1482.85 | RPO-N2.01
103034 | 2.NP mezipatro | K04.103034 | 2.NP mezipatro | 70 | RPO-N2.01
103036 | 2.NP mezipatro | K04.103036 | 2.NP mezipatro | 5276.18 | RPO-N2.01
103039 | 2.NP mezipatro | K04.103039 | 2.NP mezipatro | 1467.95 | RPO-N2.01
103041 | 2.NP mezipatro | K04.103041 | 2.NP mezipatro | 1467.95 | RPO-N2.01
103043 | 2.NP mezipatro | K04.103043 | 2.NP mezipatro | 1467.95 | RPO-N2.01
103045 | 2.NP mezipatro | K04.103045 | 2.NP mezipatro | 1467.95 | RPO-N2.01
103047 | 2.NP mezipatro | K04.103047 | 2.NP mezipatro | 1402.9 | RPO-N2.01
103048 | 2.NP mezipatro | K04.103048 | 2.NP mezipatro | 3204.46 | RPO-N2.01
103050 | 2.NP mezipatro | K04.103050 | 2.NP mezipatro | 70 | RPO-N2.01
103052 | 2.NP mezipatro | K04.103052 | 2.NP mezipatro | 142.32 | RPO-N2.01
103059 | 2.NP mezipatro | K04.103059 | 2.NP mezipatro | 70 | RPO-N2.01
103061 | 2.NP mezipatro | K04.103061 | 2.NP mezipatro | 1377.79 | RPO-N2.01
103065 | 2.NP mezipatro | K04.103065 | 2.NP mezipatro | 70 | RPO-N2.01
103067 | 2.NP mezipatro | K04.103067 | 2.NP mezipatro | 6429.53 | RPO-N2.01
103071 | 2.NP mezipatro | K04.103071 | 2.NP mezipatro | 70 | RPO-N2.01
103073 | 2.NP mezipatro | K04.103073 | 2.NP mezipatro | 5264.01 | RPO-N2.01
103077 | 2.NP mezipatro | K04.103077 | 2.NP mezipatro | 70 | RPO-N2.01
103079 | 2.NP mezipatro | K04.103079 | 2.NP mezipatro | 5121.27 | RPO-N2.01
103084 | 2.NP mezipatro | K04.103084 | 2.NP mezipatro | 5247.56 | RPO-N2.01
103135 | 1.S | K04.103135 | 1.S | 14548.2 | RPO-N2.01
103184 | 2.NP mezipatro | K04.103184 | 2.NP mezipatro | 40.39 | RPO-N2.01
103185 | 2.NP mezipatro | K04.103185 | 2.NP mezipatro | 170.71 | RPO-N2.01
103205 | 2.NP mezipatro | K04.103205 | 2.NP mezipatro | 3205.41 | RPO-N2.01
103218 | 3.NP mezipatro | K04.103218 | 3.NP mezipatro | 10355 | RPO-N3.01
103219 | 3.NP mezipatro | K04.103219 | 3.NP mezipatro | 6720.03 | RPO-N3.01
103224 | 3.NP mezipatro | K04.103224 | 3.NP mezipatro | 1164.67 | RPO-N3.01
103225 | 3.NP mezipatro | K04.103225 | 3.NP mezipatro | 4889.21 | RPO-N3.01
103226 | 3.NP mezipatro | K04.103226 | 3.NP mezipatro | 3177.8 | RPO-N3.01
103227 | 3.NP mezipatro | K04.103227 | 3.NP mezipatro | 1482.85 | RPO-N3.01
103229 | 3.NP mezipatro | K04.103229 | 3.NP mezipatro | 70 | RPO-N3.01
103231 | 3.NP mezipatro | K04.103231 | 3.NP mezipatro | 5378.29 | RPO-N3.01
103234 | 3.NP mezipatro | K04.103234 | 3.NP mezipatro | 1467.95 | RPO-N3.01
103236 | 3.NP mezipatro | K04.103236 | 3.NP mezipatro | 1467.95 | RPO-N3.01
103238 | 3.NP mezipatro | K04.103238 | 3.NP mezipatro | 1467.95 | RPO-N3.01
103242 | 3.NP mezipatro | K04.103242 | 3.NP mezipatro | 1403.26 | RPO-N3.01
103243 | 3.NP mezipatro | K04.103243 | 3.NP mezipatro | 3343.85 | RPO-N3.01
103245 | 3.NP mezipatro | K04.103245 | 3.NP mezipatro | 70 | RPO-N3.01
103247 | 3.NP mezipatro | K04.103247 | 3.NP mezipatro | 280.993 | RPO-N3.01
103255 | 3.NP mezipatro | K04.103255 | 3.NP mezipatro | 6393.77 | RPO-N3.01
103259 | 3.NP mezipatro | K04.103259 | 3.NP mezipatro | 70 | RPO-N3.01
103265 | 3.NP mezipatro | K04.103265 | 3.NP mezipatro | 70 | RPO-N3.01
103267 | 3.NP mezipatro | K04.103267 | 3.NP mezipatro | 5306.19 | RPO-N3.01
103271 | 3.NP mezipatro | K04.103271 | 3.NP mezipatro | 70 | RPO-N3.01
103273 | 3.NP mezipatro | K04.103273 | 3.NP mezipatro | 5124.48 | RPO-N3.01
103278 | 3.NP mezipatro | K04.103278 | 3.NP mezipatro | 5693.95 | RPO-N3.01
103281 | 3.NP mezipatro | K04.103281 | 3.NP mezipatro | 40.39 | RPO-N3.01
103282 | 3.NP mezipatro | K04.103282 | 3.NP mezipatro | 170.71 | RPO-N3.01
103291 | 3.NP mezipatro | K04.103291 | 3.NP mezipatro | 2212.7 | RPO-N3.01
103294 | 3.NP mezipatro | K04.103294 | 3.NP mezipatro | 2842.99 | RPO-N3.01
103335 | 1.S | K04.103335 | 1.S | 269.004 | RPO-N3.01
103337 | 1.S | K04.103337 | 1.S | 14512.1 | RPO-N3.01
103338 | 1.S | K04.103338 | 1.S | 1045 | RPO-N3.01
104031 | 1.NP | K04.104031 | 1.NP | 6551.66 | RPO-N1.11
104034 | 1.NP | K04.104034 | 1.NP | 3219.67 | RPO-N1.11
104040 | 1.NP | K04.104040 | 1.NP | 75 | RPO-N1.11
104043 | 1.NP | K04.104043 | 1.NP | 3193.56 | RPO-N1.11
104051 | 2.NP | K04.104051 | 2.NP | 6922.61 | RPO-N2.11
104052 | 2.NP | K04.104052 | 2.NP | 2957.9 | RPO-N2.11
104057 | 2.NP | K04.104057 | 2.NP | 70 | RPO-N2.11
104060 | 2.NP | K04.104060 | 2.NP | 3211.94 | RPO-N2.11
104067 | 3.NP | K04.104067 | 3.NP | 8855 | RPO-N3.11
104070 | 1.S | K04.104070 | 1.S | 14527.1 | RPO-N3.11
104071 | 1.S | K04.104071 | 1.S | 3032.17 | RPO-N3.11
104074 | 1.S | K04.104074 | 1.S | 264.004 | RPO-N3.11
104077 | 1.S | K04.104077 | 1.S | 1345 | RPO-N3.11
104113 | 3.NP | K04.104113 | 3.NP | 530.63 | RPO-N3.11
104117 | 3.NP | K04.104117 | 3.NP | 1081.77 | RPO-N3.11
104119 | 3.NP | K04.104119 | 3.NP | 1081.77 | RPO-N3.11
104121 | 3.NP | K04.104121 | 3.NP | 1081.77 | RPO-N3.11
104123 | 3.NP | K04.104123 | 3.NP | 1081.77 | RPO-N3.11
104125 | 3.NP | K04.104125 | 3.NP | 1081.77 | RPO-N3.11
104127 | 3.NP | K04.104127 | 3.NP | 1025.66 | RPO-N3.11
104128 | 3.NP | K04.104128 | 3.NP | 70 | RPO-N3.11
104130 | 3.NP | K04.104130 | 3.NP | 4669.53 | RPO-N3.11
104133 | 3.NP | K04.104133 | 3.NP | 70 | RPO-N3.11
104135 | 3.NP | K04.104135 | 3.NP | 6547.25 | RPO-N3.11
104139 | 3.NP | K04.104139 | 3.NP | 70 | RPO-N3.11
104141 | 3.NP | K04.104141 | 3.NP | 5266.55 | RPO-N3.11
104145 | 3.NP | K04.104145 | 3.NP | 70 | RPO-N3.11
104147 | 3.NP | K04.104147 | 3.NP | 5113.34 | RPO-N3.11
104151 | 3.NP | K04.104151 | 3.NP | 70 | RPO-N3.11
104153 | 3.NP | K04.104153 | 3.NP | 5294.1 | RPO-N3.11
104159 | 3.NP | K04.104159 | 3.NP | 3199.38 | RPO-N3.11
104162 | 3.NP | K04.104162 | 3.NP | 359.72 | RPO-N3.11
104163 | 3.NP | K04.104163 | 3.NP | 170.71 | RPO-N3.11
104188 | 3.NP | K04.104188 | 3.NP | 3210 | RPO-N3.11
104199 | 3.NP | K04.104199 | 3.NP | 6922.61 | RPO-N3.11
104200 | 3.NP | K04.104200 | 3.NP | 2946.9 | RPO-N3.11
104202 | 3.NP | K04.104202 | 3.NP | 70 | RPO-N3.11
104204 | 3.NP | K04.104204 | 3.NP | 3192.99 | RPO-N3.11
104245 | 3.NP | K04.104245 | 3.NP | 7794.3 | RPO-N3.11
104261 | 3.NP | K04.104261 | 3.NP | 70 | RPO-N3.11
104264 | 3.NP | K04.104264 | 3.NP | 125.25 | RPO-N3.11
104284 | 3.NP | K04.104284 | 3.NP | 1082.41 | RPO-N3.11
104324 | 3.NP | K04.104324 | 3.NP | 70 | RPO-N3.11
104327 | 3.NP | K04.104327 | 3.NP | 1343.63 | RPO-N3.11
106835 | 4.NP | K04.106835 | 4.NP | 120 | RPO-N4.11
106838 | 4.NP | K04.106838 | 4.NP | 7042.45 | RPO-N4.11
106846 | 5.NP | K04.106846 | 5.NP | 16835 | RPO-N5.11
106847 | 1.S | K04.106847 | 1.S | 416.6 | RPO-N5.11
106848 | 1.S | K04.106848 | 1.S | 575.098 | RPO-N5.11
106849 | 1.S | K04.106849 | 1.S | 13518 | RPO-N5.11
106853 | 1.S | K04.106853 | 1.S | 254.004 | RPO-N5.11
106856 | 1.S | K04.106856 | 1.S | 1385 | RPO-N5.11
106898 | 5.NP | K04.106898 | 5.NP | 970.3 | RPO-N5.11
106901 | 5.NP | K04.106901 | 5.NP | 22292.7 | RPO-N5.11
106915 | 5.NP | K04.106915 | 5.NP | 297.33 | RPO-N5.11
106916 | 5.NP | K04.106916 | 5.NP | 100 | RPO-N5.11
106933 | 5.NP | K04.106933 | 5.NP | 2584.04 | RPO-N5.11
106947 | 5.NP | K04.106947 | 5.NP | 170 | RPO-N5.11
106950 | 5.NP | K04.106950 | 5.NP | 586.79 | RPO-N5.11
106961 | 5.NP | K04.106961 | 5.NP | 2626.81 | RPO-N5.11
106964 | 5.NP | K04.106964 | 5.NP | 537.65 | RPO-N5.11
106967 | 5.NP | K04.106967 | 5.NP | 170 | RPO-N5.11
106970 | 5.NP | K04.106970 | 5.NP | 175.35 | RPO-N5.11
106975 | 5.NP | K04.106975 | 5.NP | 210.933 | RPO-N5.11
106980 | 5.NP | K04.106980 | 5.NP | 170 | RPO-N5.11
106983 | 5.NP | K04.106983 | 5.NP | 4360.31 | RPO-N5.11
117489 | 5.NP | K04.117489 | 5.NP | 14765 | RPO-KL-SF 1.1.01
117490 | 1.S | K04.117490 | 1.S | 464.68 | RPO-KL-SF 1.1.01
117491 | 1.S | K04.117491 | 1.S | 515.72 | RPO-KL-SF 1.1.01
117492 | 1.S | K04.117492 | 1.S | 13536.3 | RPO-KL-SF 1.1.01
117493 | 1.S | K04.117493 | 1.S | 3131.05 | RPO-KL-SF 1.1.01
117496 | 1.S | K04.117496 | 1.S | 239.004 | RPO-KL-SF 1.1.01
117499 | 1.S | K04.117499 | 1.S | 1385 | RPO-KL-SF 1.1.01
117571 | 5.NP mezipatro | K04.117571 | 5.NP mezipatro | 1364.47 | RPO-KL-SF 1.1.01
117625 | 5.NP mezipatro | K04.117625 | 5.NP mezipatro | 300 | RPO-KL-SF 1.1.01
117644 | 5.NP mezipatro | K04.117644 | 5.NP mezipatro | 198.71 | RPO-KL-SF 1.1.01
123806 | 1.S | K04.123806 | 1.S | 3101.05 | RPO-N5.11
123814 | 1.S | K04.123814 | 1.S | 1095.37 | RPO-N5.11
123829 | 1.S | K04.123829 | 1.S | 1331 | RPO-N5.11
124067 | 1.S | K04.124067 | 1.S | 299.004 | RPO-N0.06
124068 | 1.S | K04.124068 | 1.S | 1385 | RPO-N0.06
124139 | 1.S | K04.124139 | 1.S | 3011.05 | RPO-N0.06
124140 | 1.S | K04.124140 | 1.S | 1005.37 | RPO-N0.06
132250 | 1.S | K04.132250 | 1.S | 4007.41 | RPO-N0.03
132267 | 1.S | K04.132267 | 1.S | 409.63 | RPO-N0.04
132274 | 1.S | K04.132274 | 1.S | 346.44 | RPO-N0.04
132278 | 1.S | K04.132278 | 1.S | 2468.18 | RPO-N0.04
132441 | 1.S | K04.132441 | 1.S | 20 | RPO-N0.04
132630 | 1.S | K04.132630 | 1.S | 100 | RPO-N0.04
133631 | 1.S | K04.133631 | 1.S | 255.66 | RPO-N0.05
133688 | 1.S | K04.133688 | 1.S | 529.55 | RPO-N0.05
133904 | 1.NP mezipatro | K04.133904 | 1.NP mezipatro | 1454.73 | RPO-N1.01
133934 | 1.NP mezipatro | K04.133934 | 1.NP mezipatro | 70 | RPO-N1.01
133937 | 1.NP mezipatro | K04.133937 | 1.NP mezipatro | 1060.53 | RPO-N1.01
134113 | 2.NP mezipatro | K04.134113 | 2.NP mezipatro | 2212.7 | RPO-N2.01
134206 | 2.NP mezipatro | K04.134206 | 2.NP mezipatro | 1454.73 | RPO-N2.01
134238 | 2.NP mezipatro | K04.134238 | 2.NP mezipatro | 70 | RPO-N2.01
134241 | 2.NP mezipatro | K04.134241 | 2.NP mezipatro | 876.79 | RPO-N2.01
134308 | 2.NP | K04.134308 | 2.NP | 1070.06 | RPO-N2.11
134352 | 2.NP | K04.134352 | 2.NP | 70 | RPO-N2.11
134355 | 2.NP | K04.134355 | 2.NP | 3168.06 | RPO-N2.11
134444 | 3.NP mezipatro | K04.134444 | 3.NP mezipatro | 1450.54 | RPO-N3.01
134542 | 3.NP mezipatro | K04.134542 | 3.NP mezipatro | 70 | RPO-N3.01
134545 | 3.NP mezipatro | K04.134545 | 3.NP mezipatro | 1238.41 | RPO-N3.01
188844 | 1.S | K04.188844 | 1.S | 1011.06 | RPO-N0.01
188846 | 1.S | K04.188846 | 1.S | 1309.01 | RPO-N0.01
188872 | 1.S mezipatro | K04.188872 | 1.S mezipatro | 1051.78 | RPO-N1.11
188876 | 1.S mezipatro | K04.188876 | 1.S mezipatro | 1313.19 | RPO-N1.11
188885 | 1.S mezipatro | K04.188885 | 1.S mezipatro | 1047.78 | RPO-N2.11
188887 | 1.S mezipatro | K04.188887 | 1.S mezipatro | 1332.31 | RPO-N2.11
188898 | 1.S | K04.188898 | 1.S | 1021.78 | RPO-N1.01
188902 | 1.S mezipatro | K04.188902 | 1.S mezipatro | 1298.19 | RPO-N1.01
188909 | 1.S mezipatro | K04.188909 | 1.S mezipatro | 1046.84 | RPO-N0.11
188913 | 1.S mezipatro | K04.188913 | 1.S mezipatro | 1334.36 | RPO-N0.11
188932 | 1.S mezipatro | K04.188932 | 1.S mezipatro | 1125.37 | RPO-KL-SF 1.1.01
188936 | 1.S mezipatro | K04.188936 | 1.S mezipatro | 1346 | RPO-KL-SF 1.1.01
188947 | 1.S mezipatro | K04.188947 | 1.S mezipatro | 1076.84 | RPO-N3.11
188951 | 1.S mezipatro | K04.188951 | 1.S mezipatro | 1364.36 | RPO-N3.11
188959 | 1.S mezipatro | K04.188959 | 1.S mezipatro | 1046.84 | RPO-N3.01
188963 | 1.S mezipatro | K04.188963 | 1.S mezipatro | 1347.16 | RPO-N3.01
189024 | 1.S mezipatro | K04.189024 | 1.S mezipatro | 1098.6 | RPO-N0.05
189028 | 1.S mezipatro | K04.189028 | 1.S mezipatro | 1364.36 | RPO-N0.05
189059 | 1.S | K04.189059 | 1.S | 1076.84 | RPO-N0.03
189083 | 1.S | K04.189083 | 1.S | 79.52 | RPO-N0.03
189087 | 1.S | K04.189087 | 1.S | 1495.09 | RPO-N0.03
189106 | 1.S | K04.189106 | 1.S | 1412.39 | RPO-N0.03
189179 | 1.S | K04.189179 | 1.S | 378.6 | RPO-N0.03
189328 | 1.S | K04.189328 | 1.S | 1113.6 | RPO-N4.01
189338 | 1.S | K04.189338 | 1.S | 1347.16 | RPO-N4.01
189529 | 1.S | K04.189529 | 1.S | 1083.6 | RPO-N4.11
189539 | 1.S | K04.189539 | 1.S | 1332.16 | RPO-N4.11
189801 | 1.S | K04.189801 | 1.S | 1136.42 | RPO-N0.04
189811 | 1.S | K04.189811 | 1.S | 1347.84 | RPO-N0.04
190652 | 1.S | K04.190652 | 1.S | 85 | RPO-N0.03
190655 | 1.S | K04.190655 | 1.S | 1378.98 | RPO-N0.03
190799 | 1.S | K04.190799 | 1.S | 1286 | RPO-N0.06
191123 | 1.S | K04.191123 | 1.S | 2950.99 | RPO-N1.01
192826 | 1.S | K04.192826 | 1.S | 3002.62 | RPO-N2.01
192827 | 1.S | K04.192827 | 1.S | 264.11 | RPO-N2.01
192828 | 1.S | K04.192828 | 1.S | 1325 | RPO-N2.01
192829 | 1.S mezipatro | K04.192829 | 1.S mezipatro | 1077.78 | RPO-N2.01
192830 | 1.S mezipatro | K04.192830 | 1.S mezipatro | 1347.31 | RPO-N2.01
192856 | 1.S | K04.192856 | 1.S | 2999.97 | RPO-N3.01
192872 | 1.S | K04.192872 | 1.S | 880.63 | RPO-N0.02
192873 | 1.S | K04.192873 | 1.S | 301.16 | RPO-N0.02
192874 | 1.S | K04.192874 | 1.S | 12439.5 | RPO-N0.02
192875 | 1.S | K04.192875 | 1.S | 3041.05 | RPO-N0.02
192876 | 1.S | K04.192876 | 1.S | 284.004 | RPO-N0.02
192877 | 1.S | K04.192877 | 1.S | 1385 | RPO-N0.02
192886 | 1.S mezipatro | K04.192886 | 1.S mezipatro | 1035.37 | RPO-N0.02
192887 | 1.S mezipatro | K04.192887 | 1.S mezipatro | 1301 | RPO-N0.02
192927 | 1.S | K04.192927 | 1.S | 401.55 | RPO-N0.02
192947 | 1.S | K04.192947 | 1.S | 17.039 | RPO-N0.02
203999 | 1.S | K04.203999 | 1.S | 1270 | RPO-N0.04
204020 | 1.S | K04.204020 | 1.S | 85 | RPO-N0.04
204023 | 1.S | K04.204023 | 1.S | 1792.07 | RPO-N0.04
204744 | 1.S | K04.204744 | 1.S | 35 | RPO-N0.02
204747 | 1.S | K04.204747 | 1.S | 346.17 | RPO-N0.02
204923 | 1.S | K04.204923 | 1.S | 23.22 | RPO-N0.06
204924 | 1.S | K04.204924 | 1.S | 50.5 | RPO-N0.06
204928 | 1.S | K04.204928 | 1.S | 27.073 | RPO-N0.06
207270 | 1.S mezipatro | K04.207270 | 1.S mezipatro | 1616.17 | RPO-N0.11
207294 | 1.S mezipatro | K04.207294 | 1.S mezipatro | 70 | RPO-N0.11
207297 | 1.S mezipatro | K04.207297 | 1.S mezipatro | 1706.46 | RPO-N0.11
207470 | 1.S | K04.207470 | 1.S | 2280 | RPO-N0.01
207492 | 1.S | K04.207492 | 1.S | 2267.62 | RPO-N0.01
232034 | 5.NP | K04.232034 | 5.NP | 1382.16 | RPO-N5.11
232100 | 5.NP | K04.232100 | 5.NP | 1541.22 | RPO-N5.11
232155 | 5.NP mezipatro | K04.232155 | 5.NP mezipatro | 466.17 | RPO-N5.11
232318 | 5.NP | K04.232318 | 5.NP | 186.7 | RPO-N5.11
233229 | 5.NP mezipatro | K04.233229 | 5.NP mezipatro | 1702.82 | RPO-KL-SF 1.1.01
233272 | 5.NP mezipatro | K04.233272 | 5.NP mezipatro | 1732.16 | RPO-KL-SF 1.1.01
234639 | 5.NP mezipatro | K04.234639 | 5.NP mezipatro | 250 | RPO-N5.11

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CXKH-V-J 3x2,5 (19)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 3x2,5; ElementProjectSpecificDescription: CXKH-V-J 3x2,5; ElementProjectSpecificIdentifier: K05; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 3x2,5
Pset_DistributionSystemCommon - Reference: RPO
Name (Elektroinstalační trubka bez tvarovek:CXKH-V-J 3x2,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
116763 | 1.S | K05.116763 | 1.S | 1135 | Rozvaděče
116769 | 1.S | K05.116769 | 1.S | 170 | Rozvaděče
116802 | 1.S | K05.116802 | 1.S | 1100 | Rozvaděče
116817 | 1.S | K05.116817 | 1.S | 1454.8 | Rozvaděče
116845 | 1.S | K05.116845 | 1.S | 1454.8 | Rozvaděče
116848 | 1.S | K05.116848 | 1.S | 655 | Rozvaděče
116851 | 1.S | K05.116851 | 1.S | 190 | Rozvaděče
116854 | 1.S | K05.116854 | 1.S | 1100 | Rozvaděče
192354 | 1.S | K05.192354 | 1.S | 240 | Rozvaděče
192463 | 1.S | K05.192463 | 1.S | 220 | Rozvaděče
206454 | 1.S | K05.206454 | 1.S | 3640.97 | RPO-EPS
206455 | 1.S | K05.206455 | 1.S | 3134.41 | RPO-EPS
206456 | 1.S | K05.206456 | 1.S | 264.004 | RPO-EPS
206457 | 1.S | K05.206457 | 1.S | 1285 | RPO-EPS
206460 | 1.S | K05.206460 | 1.S | 1776.83 | RPO-EPS
206461 | 1.S | K05.206461 | 1.S | 1450 | RPO-EPS
206462 | 1.S mezipatro | K05.206462 | 1.S mezipatro | 1076.84 | RPO-EPS
206465 | 1.S mezipatro | K05.206465 | 1.S mezipatro | 1364.36 | RPO-EPS
206472 | 1.S | K05.206472 | 1.S | 65 | RPO-EPS

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CXKH-V-J 4x10+CYA25ZŽ (4)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 4x10+CYA25ZŽ; ElementProjectSpecificDescription: CXKH-V-J 4x10+CYA25ZŽ; ElementProjectSpecificIdentifier: K06; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 4x10+CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:CXKH-V-J 4x10+CYA25ZŽ:...) | Reference | Length
114128 | K06.114128 | 4245.05
114136 | K06.114136 | 1030.72
114158 | K06.114158 | 1400
114203 | K06.114203 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CXKH-V-J 5x2,5 (20)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 5x2,5; ElementProjectSpecificDescription: CXKH-V-J 5x2,5; ElementProjectSpecificIdentifier: K07; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 5x2,5
Pset_DistributionSystemCommon - Reference: RPO
Name (Elektroinstalační trubka bez tvarovek:CXKH-V-J 5x2,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
80667 | Střecha | K07.80667 | Střecha | 36401.2 | RPO-SF 1.1.01
80670 | Střecha | K07.80670 | Střecha | 1310.3 | RPO-SF 1.1.01
80679 | 5.NP | K07.80679 | 5.NP | 17535 | RPO-SF 1.1.01
80684 | 1.S | K07.80684 | 1.S | 575.098 | RPO-SF 1.1.01
80685 | 1.S | K07.80685 | 1.S | 13499.7 | RPO-SF 1.1.01
80699 | 1.S | K07.80699 | 1.S | 419.928 | RPO-SF 1.1.01
124007 | 1.S | K07.124007 | 1.S | 269.004 | RPO-SF 1.1.01
124008 | 1.S | K07.124008 | 1.S | 1385 | RPO-SF 1.1.01
124009 | 1.S | K07.124009 | 1.S | 3071.05 | RPO-SF 1.1.01
124010 | 1.S | K07.124010 | 1.S | 1065.37 | RPO-SF 1.1.01
124013 | 1.S | K07.124013 | 1.S | 1316 | RPO-SF 1.1.01
206308 | 1.S | K07.206308 | 1.S | 3640.97 | RPO-NZS
206309 | 1.S | K07.206309 | 1.S | 3134.41 | RPO-NZS
206310 | 1.S | K07.206310 | 1.S | 264.004 | RPO-NZS
206311 | 1.S | K07.206311 | 1.S | 1285 | RPO-NZS
206314 | 1.S | K07.206314 | 1.S | 2846.83 | RPO-NZS
206321 | 1.S | K07.206321 | 1.S | 1450 | RPO-NZS
206324 | 1.S mezipatro | K07.206324 | 1.S mezipatro | 1076.84 | RPO-NZS
206327 | 1.S mezipatro | K07.206327 | 1.S mezipatro | 1364.36 | RPO-NZS
206406 | 1.S | K07.206406 | 1.S | 65 | RPO-NZS

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CXKH-V-O 3x1,5 (40)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-O 3x1,5; ElementProjectSpecificDescription: CXKH-V-O 3x1,5; ElementProjectSpecificIdentifier: K08; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-O 3x1,5
Pset_DistributionSystemCommon - Reference: RPO
Name (Elektroinstalační trubka bez tvarovek:CXKH-V-O 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
80777 | 1.S | K08.80777 | 1.S | 9261.3 | RPO-Stop FVE
80778 | 1.S | K08.80778 | 1.S | 3147.2 | RPO-Stop FVE
80781 | 1.S | K08.80781 | 1.S | 244.8 | RPO-Stop FVE
80785 | 1.S | K08.80785 | 1.S | 1285 | RPO-Stop FVE
80862 | 1.S | K08.80862 | 1.S | 5902.95 | RPO-Stop FVE
80891 | 1.S | K08.80891 | 1.S | 235.72 | RPO-Stop FVE
80892 | 1.S | K08.80892 | 1.S | 191.924 | RPO-Stop FVE
80925 | 1.S | K08.80925 | 1.S | 1450 | RPO-Stop FVE
81009 | 1.S | K08.81009 | 1.S | 9163.6 | RPO-Stop NAB
81010 | 1.S | K08.81010 | 1.S | 3187.7 | RPO-Stop NAB
81013 | 1.S | K08.81013 | 1.S | 244.8 | RPO-Stop NAB
81016 | 1.S | K08.81016 | 1.S | 1285 | RPO-Stop NAB
81019 | 1.S | K08.81019 | 1.S | 5902.95 | RPO-Stop NAB
81020 | 1.S | K08.81020 | 1.S | 220.72 | RPO-Stop NAB
81021 | 1.S | K08.81021 | 1.S | 191.924 | RPO-Stop NAB
81029 | 1.S | K08.81029 | 1.S | 1450 | RPO-Stop NAB
81084 | 1.S | K08.81084 | 1.S | 9501.84 | RPO-TS
81085 | 1.S | K08.81085 | 1.S | 3134.41 | RPO-TS
81088 | 1.S | K08.81088 | 1.S | 264.004 | RPO-TS
81091 | 1.S | K08.81091 | 1.S | 1285 | RPO-TS
81094 | 1.S | K08.81094 | 1.S | 5902.95 | RPO-TS
81095 | 1.S | K08.81095 | 1.S | 205.72 | RPO-TS
81096 | 1.S | K08.81096 | 1.S | 191.924 | RPO-TS
81104 | 1.S | K08.81104 | 1.S | 1450 | RPO-TS
117783 | 1.S | K08.117783 | 1.S | 9381.84 | RPO-CS
117784 | 1.S | K08.117784 | 1.S | 3092.2 | RPO-CS
117787 | 1.S | K08.117787 | 1.S | 290 | RPO-CS
117790 | 1.S | K08.117790 | 1.S | 1285 | RPO-CS
117793 | 1.S | K08.117793 | 1.S | 5902.95 | RPO-CS
117794 | 1.S | K08.117794 | 1.S | 190.72 | RPO-CS
117795 | 1.S | K08.117795 | 1.S | 191.924 | RPO-CS
117803 | 1.S | K08.117803 | 1.S | 1450 | RPO-CS
188920 | 1.S mezipatro | K08.188920 | 1.S mezipatro | 1050.84 | RPO-CS
188924 | 1.S mezipatro | K08.188924 | 1.S mezipatro | 1337.16 | RPO-CS
188971 | 1.S mezipatro | K08.188971 | 1.S mezipatro | 1076.84 | RPO-TS
188975 | 1.S mezipatro | K08.188975 | 1.S mezipatro | 1364.36 | RPO-TS
188988 | 1.S mezipatro | K08.188988 | 1.S mezipatro | 1117.8 | RPO-Stop NAB
188992 | 1.S mezipatro | K08.188992 | 1.S mezipatro | 1402.65 | RPO-Stop NAB
189000 | 1.S mezipatro | K08.189000 | 1.S mezipatro | 1096.04 | RPO-Stop FVE
189005 | 1.S mezipatro | K08.189005 | 1.S mezipatro | 1347.16 | RPO-Stop FVE

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x1,5 (1792)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x1,5; ElementProjectSpecificDescription: CYKY-J 3x1,5; ElementProjectSpecificIdentifier: K09; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x1,5
Pset_DistributionSystemCommon - Reference: R-RS
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
40913 | 1.S | K09.40913 | 1.S | 87.83 | R-RS-LM0.10
40921 | 1.S | K09.40921 | 1.S | 1425.13 | R-RS-LM0.10
40935 | 1.S | K09.40935 | 1.S | 2446.57 | R-RS-LM0.10
40945 | 1.S | K09.40945 | 1.S | 7057.03 | R-RS-LM0.10
41013 | 1.S | K09.41013 | 1.S | 2855.88 | R-RS-LM0.10
41058 | 1.S | K09.41058 | 1.S | 2050 | R-RS-LM0.10
41066 | 1.S | K09.41066 | 1.S | 200 | R-RS-LM0.10
41069 | 1.S | K09.41069 | 1.S | 3614.47 | R-RS-LM0.10
41084 | 1.S | K09.41084 | 1.S | 1413.98 | R-RS-LM0.10
41106 | 1.S | K09.41106 | 1.S | 110.72 | R-RS-LM0.10
41107 | 1.S | K09.41107 | 1.S | 354.56 | R-RS-LM0.10
41157 | 1.S | K09.41157 | 1.S | 145.4 | R-RS-LM0.10
41160 | 1.S | K09.41160 | 1.S | 2456.02 | R-RS-LM0.10
41329 | 1.S | K09.41329 | 1.S | 3575.79 | R-RS-LM0.10
41398 | 1.S | K09.41398 | 1.S | 7500 | R-RS-LM0.10
41437 | 1.S | K09.41437 | 1.S | 1141.32 | R-RS-LM0.10
41462 | 1.S | K09.41462 | 1.S | 5105.16 | R-RS-LM0.10
41760 | 1.S | K09.41760 | 1.S | 1959.68 | R-RS-LM0.10
41812 | 1.S | K09.41812 | 1.S | 748.45 | R-RS-LM0.10
41830 | 1.S | K09.41830 | 1.S | 1586.43 | R-RS-LM0.10
41910 | 1.S | K09.41910 | 1.S | 624.006 | R-RS-LM0.10
42368 | 1.S | K09.42368 | 1.S | 2470 | R-RS-LM0.10
42688 | 1.S | K09.42688 | 1.S | 103.18 | R-RS-LM0.11
42696 | 1.S | K09.42696 | 1.S | 1410.13 | R-RS-LM0.11
42705 | 1.S | K09.42705 | 1.S | 2416.57 | R-RS-LM0.11
42715 | 1.S | K09.42715 | 1.S | 5445.19 | R-RS-LM0.11
42740 | 1.S | K09.42740 | 1.S | 7860.59 | R-RS-LM0.11
42755 | 1.S | K09.42755 | 1.S | 5182.97 | R-RS-LM0.11
42766 | 1.S | K09.42766 | 1.S | 2882.86 | R-RS-LM0.11
42786 | 1.S | K09.42786 | 1.S | 7047.03 | R-RS-LM0.11
42927 | 1.S | K09.42927 | 1.S | 3487.97 | R-RS-LM0.11
42935 | 1.S | K09.42935 | 1.S | 1350 | R-RS-LM0.11
42989 | 1.S | K09.42989 | 1.S | 6383.97 | R-RS-LM0.11
48757 | 4.NP | K09.48757 | 4.NP | 3993.87 | R-RS-LM4.13
48788 | 4.NP | K09.48788 | 4.NP | 684.914 | R-RS-LM4.13
48796 | 4.NP | K09.48796 | 4.NP | 12107.9 | R-RS-LM4.13
48806 | 4.NP | K09.48806 | 4.NP | 8905.4 | R-RS-LM4.13
48849 | 4.NP | K09.48849 | 4.NP | 3066.43 | R-RS-LM4.13
48857 | 4.NP | K09.48857 | 4.NP | 3961.06 | R-RS-LM4.13
48981 | 4.NP | K09.48981 | 4.NP | 3264.3 | R-RS-LM4.13
48998 | 4.NP | K09.48998 | 4.NP | 5795.47 | R-RS-LM4.13
49013 | 4.NP | K09.49013 | 4.NP | 3696.52 | R-RS-LM4.13
49030 | 4.NP | K09.49030 | 4.NP | 2813.34 | R-RS-LM4.13
49045 | 4.NP | K09.49045 | 4.NP | 863.53 | R-RS-LM4.13
49060 | 4.NP | K09.49060 | 4.NP | 3065.97 | R-RS-LM4.13
49075 | 4.NP | K09.49075 | 4.NP | 4235.8 | R-RS-LM4.13
49096 | 4.NP | K09.49096 | 4.NP | 12066.3 | R-RS-LM4.13
49102 | 4.NP | K09.49102 | 4.NP | 7518.75 | R-RS-LM4.13
49117 | 4.NP | K09.49117 | 4.NP | 24487.7 | R-RS-LM4.13
49144 | 4.NP | K09.49144 | 4.NP | 4435 | R-RS-LM4.13
49190 | 4.NP | K09.49190 | 4.NP | 1991.52 | R-RS-LM4.13
49196 | 4.NP | K09.49196 | 4.NP | 2200.97 | R-RS-LM4.13
49207 | 4.NP | K09.49207 | 4.NP | 6450 | R-RS-LM4.13
49273 | 4.NP | K09.49273 | 4.NP | 2563.73 | R-RS-LM4.13
49300 | 4.NP | K09.49300 | 4.NP | 1471.78 | R-RS-LM4.13
49310 | 4.NP | K09.49310 | 4.NP | 3778.53 | R-RS-LM4.13
49365 | 4.NP | K09.49365 | 4.NP | 754.907 | R-RS-LM4.13
49392 | 4.NP | K09.49392 | 4.NP | 4350 | R-RS-LM4.13
49465 | 4.NP | K09.49465 | 4.NP | 2508.74 | R-RS-LM4.13
49504 | 4.NP | K09.49504 | 4.NP | 2819.93 | R-RS-LM4.13
49510 | 4.NP | K09.49510 | 4.NP | 1843.23 | R-RS-LM4.13
49521 | 4.NP | K09.49521 | 4.NP | 5150 | R-RS-LM4.13
49595 | 4.NP | K09.49595 | 4.NP | 3680.18 | R-RS-LM4.13
49604 | 4.NP | K09.49604 | 4.NP | 99.2 | R-RS-LM4.13
49614 | 4.NP | K09.49614 | 4.NP | 7400 | R-RS-LM4.13
49761 | 4.NP | K09.49761 | 4.NP | 3576.43 | R-RS-LM4.13
50252 | 4.NP | K09.50252 | 4.NP | 11900 | R-RS-LM4.13
50586 | 4.NP | K09.50586 | 4.NP | 120 | R-RS-LM4.13
50669 | 4.NP | K09.50669 | 4.NP | 120 | R-RS-LM4.13
50713 | 4.NP | K09.50713 | 4.NP | 1258.27 | R-RS-LM4.13
50714 | 4.NP | K09.50714 | 4.NP | 241.42 | R-RS-LM4.13
50789 | 4.NP | K09.50789 | 4.NP | 120 | R-RS-LM4.13
50792 | 4.NP | K09.50792 | 4.NP | 1631.81 | R-RS-LM4.13
50870 | 4.NP | K09.50870 | 4.NP | 120 | R-RS-LM4.13
50873 | 4.NP | K09.50873 | 4.NP | 10499.7 | R-RS-LM4.13
50946 | 4.NP | K09.50946 | 4.NP | 120 | R-RS-LM4.13
51019 | 4.NP | K09.51019 | 4.NP | 120 | R-RS-LM4.13
51022 | 4.NP | K09.51022 | 4.NP | 8716.89 | R-RS-LM4.13
51040 | 4.NP | K09.51040 | 4.NP | 190.72 | R-RS-LM4.13
51041 | 4.NP | K09.51041 | 4.NP | 241.42 | R-RS-LM4.13
51911 | 1.S | K09.51911 | 1.S | 151.39 | R-RS-LM4.14
51912 | 1.S | K09.51912 | 1.S | 1364.05 | R-RS-LM4.14
51915 | 1.S | K09.51915 | 1.S | 2293.79 | R-RS-LM4.14
51918 | 1.S | K09.51918 | 1.S | 6689.05 | R-RS-LM4.14
51921 | 1.S | K09.51921 | 1.S | 16021.5 | R-RS-LM4.14
51925 | 4.NP | K09.51925 | 4.NP | 11900 | R-RS-LM4.14
51935 | 1.S | K09.51935 | 1.S | 950 | R-RS-LM4.14
51963 | 4.NP | K09.51963 | 4.NP | 4008.87 | R-RS-LM4.14
51966 | 4.NP | K09.51966 | 4.NP | 11104.6 | R-RS-LM4.14
52014 | 4.NP | K09.52014 | 4.NP | 12092.9 | R-RS-LM4.14
52022 | 4.NP | K09.52022 | 4.NP | 7149.9 | R-RS-LM4.14
52277 | 4.NP | K09.52277 | 4.NP | 2914.98 | R-RS-LM4.14
52295 | 4.NP | K09.52295 | 4.NP | 3853.93 | R-RS-LM4.14
52310 | 4.NP | K09.52310 | 4.NP | 3701.15 | R-RS-LM4.14
52325 | 4.NP | K09.52325 | 4.NP | 3853.93 | R-RS-LM4.14
52334 | 4.NP | K09.52334 | 4.NP | 120 | R-RS-LM4.14
52337 | 4.NP | K09.52337 | 4.NP | 3252.3 | R-RS-LM4.14
52367 | 4.NP | K09.52367 | 4.NP | 794.072 | R-RS-LM4.14
52379 | 4.NP | K09.52379 | 4.NP | 6247.27 | R-RS-LM4.14
52458 | 4.NP | K09.52458 | 4.NP | 120 | R-RS-LM4.14
52461 | 4.NP | K09.52461 | 4.NP | 7689.89 | R-RS-LM4.14
52473 | 4.NP | K09.52473 | 4.NP | 3274.89 | R-RS-LM4.14
52481 | 4.NP | K09.52481 | 4.NP | 2358.46 | R-RS-LM4.14
52491 | 4.NP | K09.52491 | 4.NP | 6185.31 | R-RS-LM4.14
52512 | 4.NP | K09.52512 | 4.NP | 725 | R-RS-LM4.14
52520 | 4.NP | K09.52520 | 4.NP | 1879.91 | R-RS-LM4.14
52548 | 4.NP | K09.52548 | 4.NP | 1058.87 | R-RS-LM4.14
52556 | 4.NP | K09.52556 | 4.NP | 2130 | R-RS-LM4.14
52583 | 4.NP | K09.52583 | 4.NP | 3080.97 | R-RS-LM4.14
52593 | 4.NP | K09.52593 | 4.NP | 5094.56 | R-RS-LM4.14
52610 | 4.NP | K09.52610 | 4.NP | 3100.97 | R-RS-LM4.14
52618 | 4.NP | K09.52618 | 4.NP | 680 | R-RS-LM4.14
52635 | 4.NP | K09.52635 | 4.NP | 2875.29 | R-RS-LM4.14
52645 | 4.NP | K09.52645 | 4.NP | 2186.9 | R-RS-LM4.14
52655 | 4.NP | K09.52655 | 4.NP | 5050 | R-RS-LM4.14
52672 | 4.NP | K09.52672 | 4.NP | 556.59 | R-RS-LM4.14
52682 | 4.NP | K09.52682 | 4.NP | 2396.87 | R-RS-LM4.14
52687 | 4.NP | K09.52687 | 4.NP | 1805 | R-RS-LM4.14
52697 | 4.NP | K09.52697 | 4.NP | 236.5 | R-RS-LM4.14
52705 | 4.NP | K09.52705 | 4.NP | 58.13 | R-RS-LM4.14
52715 | 4.NP | K09.52715 | 4.NP | 347.28 | R-RS-LM4.14
52723 | 4.NP | K09.52723 | 4.NP | 2700.97 | R-RS-LM4.14
52733 | 4.NP | K09.52733 | 4.NP | 5038.02 | R-RS-LM4.14
53007 | 1.S | K09.53007 | 1.S | 136.39 | R-RS-LM4.04
53008 | 1.S | K09.53008 | 1.S | 1379.05 | R-RS-LM4.04
53011 | 1.S | K09.53011 | 1.S | 2323.79 | R-RS-LM4.04
53014 | 1.S | K09.53014 | 1.S | 6734.05 | R-RS-LM4.04
53017 | 1.S | K09.53017 | 1.S | 16036.5 | R-RS-LM4.04
53021 | 4.NP mezipatro | K09.53021 | 4.NP mezipatro | 13400 | R-RS-LM4.04
53031 | 1.S | K09.53031 | 1.S | 950 | R-RS-LM4.04
53921 | 4.NP | K09.53921 | 4.NP | 2589.78 | R-RS-LM4.14
53982 | 4.NP | K09.53982 | 4.NP | 120 | R-RS-LM4.14
53985 | 4.NP | K09.53985 | 4.NP | 4036.03 | R-RS-LM4.14
54033 | 4.NP | K09.54033 | 4.NP | 3428.48 | R-RS-LM4.14
54166 | 4.NP | K09.54166 | 4.NP | 578.89 | R-RS-LM4.14
54181 | 4.NP | K09.54181 | 4.NP | 558.89 | R-RS-LM4.14
54300 | 4.NP | K09.54300 | 4.NP | 4110.63 | R-RS-LM4.14
54337 | 4.NP | K09.54337 | 4.NP | 1163.84 | R-RS-LM4.14
54458 | 4.NP | K09.54458 | 4.NP | 76.4 | R-RS-LM4.14
54582 | 4.NP | K09.54582 | 4.NP | 4600 | R-RS-LM4.14
54649 | 4.NP | K09.54649 | 4.NP | 1850 | R-RS-LM4.14
54691 | 4.NP mezipatro | K09.54691 | 4.NP mezipatro | 2094.63 | R-RS-LM4.03
54694 | 4.NP mezipatro | K09.54694 | 4.NP mezipatro | 1705 | R-RS-LM4.03
54700 | 4.NP mezipatro | K09.54700 | 4.NP mezipatro | 6122.62 | R-RS-LM4.03
54722 | 4.NP mezipatro | K09.54722 | 4.NP mezipatro | 1705 | R-RS-LM4.03
54725 | 4.NP mezipatro | K09.54725 | 4.NP mezipatro | 350 | R-RS-LM4.03
54730 | 4.NP mezipatro | K09.54730 | 4.NP mezipatro | 621.016 | R-RS-LM4.03
54736 | 4.NP mezipatro | K09.54736 | 4.NP mezipatro | 2530 | R-RS-LM4.03
54739 | 4.NP mezipatro | K09.54739 | 4.NP mezipatro | 3640 | R-RS-LM4.03
54744 | 4.NP mezipatro | K09.54744 | 4.NP mezipatro | 1207.8 | R-RS-LM4.03
54748 | 4.NP mezipatro | K09.54748 | 4.NP mezipatro | 7390 | R-RS-LM4.03
54756 | 4.NP mezipatro | K09.54756 | 4.NP mezipatro | 5318.07 | R-RS-LM4.03
54759 | 4.NP mezipatro | K09.54759 | 4.NP mezipatro | 637.88 | R-RS-LM4.03
54764 | 4.NP mezipatro | K09.54764 | 4.NP mezipatro | 5450.21 | R-RS-LM4.03
54768 | 4.NP mezipatro | K09.54768 | 4.NP mezipatro | 1112.12 | R-RS-LM4.03
54772 | 4.NP mezipatro | K09.54772 | 4.NP mezipatro | 5081.88 | R-RS-LM4.03
54775 | 4.NP mezipatro | K09.54775 | 4.NP mezipatro | 2726.28 | R-RS-LM4.03
54778 | 4.NP mezipatro | K09.54778 | 4.NP mezipatro | 452.8 | R-RS-LM4.03
54783 | 4.NP mezipatro | K09.54783 | 4.NP mezipatro | 5108.01 | R-RS-LM4.03
54787 | 4.NP mezipatro | K09.54787 | 4.NP mezipatro | 502.8 | R-RS-LM4.03
56070 | 4.NP mezipatro | K09.56070 | 4.NP mezipatro | 19640 | R-RS-LM4.03
56077 | 4.NP mezipatro | K09.56077 | 4.NP mezipatro | 1609.07 | R-RS-LM4.03
56083 | 4.NP mezipatro | K09.56083 | 4.NP mezipatro | 120 | R-RS-LM4.03
56086 | 4.NP mezipatro | K09.56086 | 4.NP mezipatro | 5454.03 | R-RS-LM4.03
56110 | 4.NP mezipatro | K09.56110 | 4.NP mezipatro | 741.12 | R-RS-LM4.03
56116 | 4.NP mezipatro | K09.56116 | 4.NP mezipatro | 120 | R-RS-LM4.03
56119 | 4.NP mezipatro | K09.56119 | 4.NP mezipatro | 2287.7 | R-RS-LM4.03
56133 | 4.NP mezipatro | K09.56133 | 4.NP mezipatro | 1871.9 | R-RS-LM4.03
56190 | 1.S | K09.56190 | 1.S | 166.39 | R-RS-LM4.13
56191 | 1.S | K09.56191 | 1.S | 1349.05 | R-RS-LM4.13
56194 | 1.S | K09.56194 | 1.S | 2263.79 | R-RS-LM4.13
56197 | 1.S | K09.56197 | 1.S | 6659.05 | R-RS-LM4.13
56200 | 1.S | K09.56200 | 1.S | 16006.5 | R-RS-LM4.13
56212 | 1.S | K09.56212 | 1.S | 950 | R-RS-LM4.13
56545 | 1.S | K09.56545 | 1.S | 121.39 | R-RS-LM2.04
56546 | 1.S | K09.56546 | 1.S | 1394.05 | R-RS-LM2.04
56549 | 1.S | K09.56549 | 1.S | 2368.79 | R-RS-LM2.04
56552 | 1.S | K09.56552 | 1.S | 7148.13 | R-RS-LM2.04
56555 | 1.S | K09.56555 | 1.S | 16106.5 | R-RS-LM2.04
56567 | 1.S | K09.56567 | 1.S | 910 | R-RS-LM2.04
56570 | 2.NP mezipatro | K09.56570 | 2.NP mezipatro | 2278.79 | R-RS-LM2.04
56572 | 2.NP mezipatro | K09.56572 | 2.NP mezipatro | 3139.87 | R-RS-LM2.04
56595 | 2.NP mezipatro | K09.56595 | 2.NP mezipatro | 120.965 | R-RS-LM2.04
56599 | 2.NP mezipatro | K09.56599 | 2.NP mezipatro | 2954.36 | R-RS-LM2.04
56601 | 2.NP mezipatro | K09.56601 | 2.NP mezipatro | 120 | R-RS-LM2.04
56603 | 2.NP mezipatro | K09.56603 | 2.NP mezipatro | 7543.3 | R-RS-LM2.04
56607 | 2.NP mezipatro | K09.56607 | 2.NP mezipatro | 2954.36 | R-RS-LM2.04
56609 | 2.NP mezipatro | K09.56609 | 2.NP mezipatro | 120 | R-RS-LM2.04
56611 | 2.NP mezipatro | K09.56611 | 2.NP mezipatro | 5946.94 | R-RS-LM2.04
56615 | 2.NP mezipatro | K09.56615 | 2.NP mezipatro | 2589.03 | R-RS-LM2.04
56624 | 2.NP mezipatro | K09.56624 | 2.NP mezipatro | 2092.55 | R-RS-LM2.04
56628 | 2.NP mezipatro | K09.56628 | 2.NP mezipatro | 10390.6 | R-RS-LM2.04
56640 | 2.NP mezipatro | K09.56640 | 2.NP mezipatro | 1640 | R-RS-LM2.04
56643 | 2.NP mezipatro | K09.56643 | 2.NP mezipatro | 2437.48 | R-RS-LM2.04
56653 | 2.NP mezipatro | K09.56653 | 2.NP mezipatro | 5150 | R-RS-LM2.04
56669 | 2.NP mezipatro | K09.56669 | 2.NP mezipatro | 6052.12 | R-RS-LM2.04
56670 | 2.NP mezipatro | K09.56670 | 2.NP mezipatro | 125.64 | R-RS-LM2.04
56679 | 2.NP mezipatro | K09.56679 | 2.NP mezipatro | 175.974 | R-RS-LM2.04
56682 | 2.NP mezipatro | K09.56682 | 2.NP mezipatro | 1858.7 | R-RS-LM2.04
56685 | 2.NP mezipatro | K09.56685 | 2.NP mezipatro | 167.057 | R-RS-LM2.04
56688 | 2.NP mezipatro | K09.56688 | 2.NP mezipatro | 1798.59 | R-RS-LM2.04
56694 | 2.NP mezipatro | K09.56694 | 2.NP mezipatro | 1845.36 | R-RS-LM2.04
56697 | 2.NP mezipatro | K09.56697 | 2.NP mezipatro | 1698.59 | R-RS-LM2.04
56700 | 2.NP mezipatro | K09.56700 | 2.NP mezipatro | 4922.91 | R-RS-LM2.04
56703 | 2.NP mezipatro | K09.56703 | 2.NP mezipatro | 3970 | R-RS-LM2.04
57336 | 1.S | K09.57336 | 1.S | 113.022 | R-RS-LM0.12
57337 | 1.S | K09.57337 | 1.S | 1373.05 | R-RS-LM0.12
57340 | 1.S | K09.57340 | 1.S | 2386.57 | R-RS-LM0.12
57343 | 1.S | K09.57343 | 1.S | 6982.03 | R-RS-LM0.12
57346 | 1.S | K09.57346 | 1.S | 16148.1 | R-RS-LM0.12
57358 | 1.S | K09.57358 | 1.S | 870 | R-RS-LM0.12
57361 | 1.S mezipatro | K09.57361 | 1.S mezipatro | 2396.08 | R-RS-LM0.12
57363 | 1.S mezipatro | K09.57363 | 1.S mezipatro | 1957.09 | R-RS-LM0.12
57390 | 1.S mezipatro | K09.57390 | 1.S mezipatro | 2276.64 | R-RS-LM0.12
57392 | 1.S mezipatro | K09.57392 | 1.S mezipatro | 120 | R-RS-LM0.12
57394 | 1.S mezipatro | K09.57394 | 1.S mezipatro | 7696.16 | R-RS-LM0.12
57398 | 1.S mezipatro | K09.57398 | 1.S mezipatro | 2278.91 | R-RS-LM0.12
57400 | 1.S mezipatro | K09.57400 | 1.S mezipatro | 120 | R-RS-LM0.12
57402 | 1.S mezipatro | K09.57402 | 1.S mezipatro | 7368.38 | R-RS-LM0.12
57406 | 1.S mezipatro | K09.57406 | 1.S mezipatro | 1685.8 | R-RS-LM0.12
57407 | 1.S mezipatro | K09.57407 | 1.S mezipatro | 140.72 | R-RS-LM0.12
57408 | 1.S mezipatro | K09.57408 | 1.S mezipatro | 241.42 | R-RS-LM0.12
57451 | 1.S mezipatro | K09.57451 | 1.S mezipatro | 2675 | R-RS-LM0.12
57454 | 1.S mezipatro | K09.57454 | 1.S mezipatro | 224.78 | R-RS-LM0.12
57460 | 1.S mezipatro | K09.57460 | 1.S mezipatro | 4950 | R-RS-LM0.12
57470 | 1.S mezipatro | K09.57470 | 1.S mezipatro | 1070.78 | R-RS-LM0.12
57473 | 1.S mezipatro | K09.57473 | 1.S mezipatro | 1010 | R-RS-LM0.12
57476 | 1.S mezipatro | K09.57476 | 1.S mezipatro | 141.75 | R-RS-LM0.12
57479 | 1.S mezipatro | K09.57479 | 1.S mezipatro | 1300.86 | R-RS-LM0.12
57485 | 1.S mezipatro | K09.57485 | 1.S mezipatro | 122.44 | R-RS-LM0.12
57488 | 1.S mezipatro | K09.57488 | 1.S mezipatro | 130.55 | R-RS-LM0.12
57491 | 1.S mezipatro | K09.57491 | 1.S mezipatro | 3775 | R-RS-LM0.12
57494 | 1.S mezipatro | K09.57494 | 1.S mezipatro | 3968.42 | R-RS-LM0.12
57713 | 4.NP mezipatro | K09.57713 | 4.NP mezipatro | 13243 | R-RS-LM4.03
57719 | 4.NP mezipatro | K09.57719 | 4.NP mezipatro | 7914.35 | R-RS-LM4.03
57724 | 4.NP mezipatro | K09.57724 | 4.NP mezipatro | 3255.87 | R-RS-LM4.03
57746 | 4.NP mezipatro | K09.57746 | 4.NP mezipatro | 140.72 | R-RS-LM4.03
57747 | 4.NP mezipatro | K09.57747 | 4.NP mezipatro | 241.42 | R-RS-LM4.03
57766 | 4.NP mezipatro | K09.57766 | 4.NP mezipatro | 3638.01 | R-RS-LM4.03
57790 | 4.NP mezipatro | K09.57790 | 4.NP mezipatro | 120 | R-RS-LM4.03
57793 | 4.NP mezipatro | K09.57793 | 4.NP mezipatro | 8638.23 | R-RS-LM4.03
57821 | 4.NP mezipatro | K09.57821 | 4.NP mezipatro | 3632.96 | R-RS-LM4.03
57885 | 4.NP mezipatro | K09.57885 | 4.NP mezipatro | 2194.71 | R-RS-LM4.03
57893 | 4.NP mezipatro | K09.57893 | 4.NP mezipatro | 1699.95 | R-RS-LM4.03
57904 | 4.NP mezipatro | K09.57904 | 4.NP mezipatro | 5142.5 | R-RS-LM4.03
57937 | 4.NP mezipatro | K09.57937 | 4.NP mezipatro | 120 | R-RS-LM4.03
57940 | 4.NP mezipatro | K09.57940 | 4.NP mezipatro | 25136.6 | R-RS-LM4.03
59697 | 2.NP | K09.59697 | 2.NP | 1066.59 | R-RS-LM2.13
59700 | 2.NP | K09.59700 | 2.NP | 12192.1 | R-RS-LM2.13
59703 | 2.NP | K09.59703 | 2.NP | 26317.6 | R-RS-LM2.13
59704 | 2.NP | K09.59704 | 2.NP | 3551.19 | R-RS-LM2.13
59705 | 2.NP | K09.59705 | 2.NP | 4033.45 | R-RS-LM2.13
59708 | 2.NP | K09.59708 | 2.NP | 3264.31 | R-RS-LM2.13
59709 | 2.NP | K09.59709 | 2.NP | 7296.87 | R-RS-LM2.13
59710 | 2.NP | K09.59710 | 2.NP | 1164.04 | R-RS-LM2.13
59711 | 2.NP | K09.59711 | 2.NP | 2422.34 | R-RS-LM2.13
59712 | 2.NP | K09.59712 | 2.NP | 1190.8 | R-RS-LM2.13
