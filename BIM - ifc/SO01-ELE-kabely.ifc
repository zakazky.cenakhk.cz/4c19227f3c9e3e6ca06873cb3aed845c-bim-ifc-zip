Properties of the parts of a building model (IFC4), part 7 of 7

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5 (18)
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5:...) | In | Reference | StoreyProjectSpecificIdentifier | Length
117095 | 1.S | K16.117095 | 1.S | 2323.79
117098 | 1.S | K16.117098 | 1.S | 6821.54
117099 | 1.S | K16.117099 | 1.S | 950
117102 | 1.S | K16.117102 | 1.S | 16031.5
117107 | 5.NP | K16.117107 | 5.NP | 17200
117297 | 5.NP mezipatro | K16.117297 | 5.NP mezipatro | 248.71
117307 | 5.NP mezipatro | K16.117307 | 5.NP mezipatro | 2063.55
117316 | 5.NP mezipatro | K16.117316 | 5.NP mezipatro | 836.44
117326 | 5.NP mezipatro | K16.117326 | 5.NP mezipatro | 330
117400 | 5.NP mezipatro | K16.117400 | 5.NP mezipatro | 1550

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 5x16 + CYKY-O 3x1,5 (30)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 5x16 + CYKY-O 3x1,5; ElementProjectSpecificDescription: CYKY-J 5x16 + CYKY-O 3x1,5; ElementProjectSpecificIdentifier: K19; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 5x16 + CYKY-O 3x1,5
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: RE-G
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 5x16 + CYKY-O 3x1,5:...) | CZ_ElementCommon, Reference | Length | Pset_JunctionBoxTypeCommon, Reference
107001 | K19.107001 | 37716.6 | RE-G1
107206 | K19.107206 | 458.022 | RE-G1
107214 | K19.107214 | 100 | RE-G1
107274 | K19.107274 | 2500 | RE-G1
107380 | K19.107380 | 1406.5 | RE-G1
107381 | K19.107381 | 200 | RE-G1
107462 | K19.107462 | 1400 | RE-G1
107556 | K19.107556 | 7125.37 | RE-G2
107558 | K19.107558 | 100 | RE-G2
107572 | K19.107572 | 1400 | RE-G2
107590 | K19.107590 | 31316.5 | RE-G3
107591 | K19.107591 | 443.022 | RE-G3
107592 | K19.107592 | 100 | RE-G3
107593 | K19.107593 | 2500 | RE-G3
107598 | K19.107598 | 1656.5 | RE-G3
107599 | K19.107599 | 200 | RE-G3
107606 | K19.107606 | 1400 | RE-G3
107630 | K19.107630 | 24344.3 | RE-G4
107631 | K19.107631 | 428.022 | RE-G4
107632 | K19.107632 | 100 | RE-G4
107633 | K19.107633 | 2500 | RE-G4
107638 | K19.107638 | 3.78 | RE-G4
107639 | K19.107639 | 200 | RE-G4
107646 | K19.107646 | 1400 | RE-G4
139178 | K19.139178 | 7902.31 | RE-G2
139217 | K19.139217 | 18390.5 | RE-G2
139261 | K19.139261 | 7829.76 | RE-G2
139343 | K19.139343 | 100 | RE-G2
139369 | K19.139369 | 130 | RE-G2
139550 | K19.139550 | 2600 | RE-G2

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 5x2,5 + CYA6ZŽ (56)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 5x2,5 + CYA6ZŽ; ElementProjectSpecificDescription: CYKY-J 5x2,5 + CYA6ZŽ; ElementProjectSpecificIdentifier: K17; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 5x2,5 + CYA6ZŽ
Pset_DistributionSystemCommon - Reference: R-RS
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 5x2,5 + CYA6ZŽ:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
94198 | 1.S mezipatro | K17.94198 | 1.S mezipatro | 3849.92 | R-RS-VZT-01.1.01
94210 | 1.S mezipatro | K17.94210 | 1.S mezipatro | 962.089 | R-RS-VZT-01.1.01
94218 | 1.S mezipatro | K17.94218 | 1.S mezipatro | 2436.18 | R-RS-VZT-01.1.01
94266 | 1.S mezipatro | K17.94266 | 1.S mezipatro | 450 | R-RS-VZT-01.1.01
94429 | 1.S mezipatro | K17.94429 | 1.S mezipatro | 4537.86 | R-RS-VZT-01.1.01
94465 | 1.S mezipatro | K17.94465 | 1.S mezipatro | 31518.8 | R-RS-VZT-01.1.01
94466 | 1.S mezipatro | K17.94466 | 1.S mezipatro | 241.42 | R-RS-VZT-01.1.01
94543 | 1.S | K17.94543 | 1.S | 151.39 | R-RS-VZT-01.1.01
94544 | 1.S | K17.94544 | 1.S | 1367.02 | R-RS-VZT-01.1.01
94547 | 1.S | K17.94547 | 1.S | 2310.7 | R-RS-VZT-01.1.01
94550 | 1.S | K17.94550 | 1.S | 6991.01 | R-RS-VZT-01.1.01
94557 | 1.S mezipatro | K17.94557 | 1.S mezipatro | 1480 | R-RS-VZT-01.1.01
94558 | 1.S | K17.94558 | 1.S | 16085.5 | R-RS-VZT-01.1.01
94561 | 1.S | K17.94561 | 1.S | 870 | R-RS-VZT-01.1.01
95108 | 1.NP mezipatro | K17.95108 | 1.NP mezipatro | 4128.78 | R-RS-VZT-1.1.01
95111 | 1.NP mezipatro | K17.95111 | 1.NP mezipatro | 1057.09 | R-RS-VZT-1.1.01
95114 | 1.NP mezipatro | K17.95114 | 1.NP mezipatro | 2244.48 | R-RS-VZT-1.1.01
95115 | 1.NP mezipatro | K17.95115 | 1.NP mezipatro | 638.55 | R-RS-VZT-1.1.01
95116 | 1.NP mezipatro | K17.95116 | 1.NP mezipatro | 4847.2 | R-RS-VZT-1.1.01
95125 | 1.S | K17.95125 | 1.S | 151.39 | R-RS-VZT-1.1.01
95126 | 1.S | K17.95126 | 1.S | 1379.05 | R-RS-VZT-1.1.01
95129 | 1.S | K17.95129 | 1.S | 2323.79 | R-RS-VZT-1.1.01
95132 | 1.S | K17.95132 | 1.S | 7073.03 | R-RS-VZT-1.1.01
95135 | 1.NP mezipatro | K17.95135 | 1.NP mezipatro | 4460 | R-RS-VZT-1.1.01
95136 | 1.S | K17.95136 | 1.S | 16111.5 | R-RS-VZT-1.1.01
95137 | 1.S | K17.95137 | 1.S | 890 | R-RS-VZT-1.1.01
95269 | 1.NP mezipatro | K17.95269 | 1.NP mezipatro | 31894.5 | R-RS-VZT-1.1.01
95270 | 1.NP mezipatro | K17.95270 | 1.NP mezipatro | 241.42 | R-RS-VZT-1.1.01
95319 | 2.NP mezipatro | K17.95319 | 2.NP mezipatro | 4035.91 | R-RS-VZT-2.1.01
95322 | 2.NP mezipatro | K17.95322 | 2.NP mezipatro | 1072.51 | R-RS-VZT-2.1.01
95325 | 2.NP mezipatro | K17.95325 | 2.NP mezipatro | 2293.79 | R-RS-VZT-2.1.01
95326 | 2.NP mezipatro | K17.95326 | 2.NP mezipatro | 575 | R-RS-VZT-2.1.01
95327 | 2.NP mezipatro | K17.95327 | 2.NP mezipatro | 4977.19 | R-RS-VZT-2.1.01
95328 | 1.S | K17.95328 | 1.S | 151.39 | R-RS-VZT-2.1.01
95329 | 1.S | K17.95329 | 1.S | 1379.05 | R-RS-VZT-2.1.01
95332 | 1.S | K17.95332 | 1.S | 2353.79 | R-RS-VZT-2.1.01
95335 | 1.S | K17.95335 | 1.S | 7148.13 | R-RS-VZT-2.1.01
95338 | 2.NP mezipatro | K17.95338 | 2.NP mezipatro | 7440 | R-RS-VZT-2.1.01
95339 | 1.S | K17.95339 | 1.S | 16121.5 | R-RS-VZT-2.1.01
95340 | 1.S | K17.95340 | 1.S | 910 | R-RS-VZT-2.1.01
95543 | 2.NP mezipatro | K17.95543 | 2.NP mezipatro | 31704.8 | R-RS-VZT-2.1.01
95544 | 2.NP mezipatro | K17.95544 | 2.NP mezipatro | 241.42 | R-RS-VZT-2.1.01
95590 | 3.NP mezipatro | K17.95590 | 3.NP mezipatro | 4097.15 | R-RS-VZT-3.1.01
95593 | 3.NP mezipatro | K17.95593 | 3.NP mezipatro | 877.61 | R-RS-VZT-3.1.01
95596 | 3.NP mezipatro | K17.95596 | 3.NP mezipatro | 2283.79 | R-RS-VZT-3.1.01
95597 | 3.NP mezipatro | K17.95597 | 3.NP mezipatro | 606.24 | R-RS-VZT-3.1.01
95598 | 3.NP mezipatro | K17.95598 | 3.NP mezipatro | 4977.19 | R-RS-VZT-3.1.01
95599 | 1.S | K17.95599 | 1.S | 151.39 | R-RS-VZT-3.1.01
95600 | 1.S | K17.95600 | 1.S | 1379.05 | R-RS-VZT-3.1.01
95603 | 1.S | K17.95603 | 1.S | 2323.79 | R-RS-VZT-3.1.01
95606 | 1.S | K17.95606 | 1.S | 6931.53 | R-RS-VZT-3.1.01
95609 | 3.NP mezipatro | K17.95609 | 3.NP mezipatro | 10420 | R-RS-VZT-3.1.01
95610 | 1.S | K17.95610 | 1.S | 16071.5 | R-RS-VZT-3.1.01
95611 | 1.S | K17.95611 | 1.S | 930 | R-RS-VZT-3.1.01
95622 | 3.NP mezipatro | K17.95622 | 3.NP mezipatro | 31726.5 | R-RS-VZT-3.1.01
95623 | 3.NP mezipatro | K17.95623 | 3.NP mezipatro | 241.42 | R-RS-VZT-3.1.01

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 5x4 + CYA 6ZŽ (25)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 5x4 + CYA 6ZŽ; ElementProjectSpecificDescription: CYKY-J 5x4 + CYA 6ZŽ; ElementProjectSpecificIdentifier: K18; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 5x4 + CYA 6ZŽ
Pset_DistributionSystemCommon - Reference: R-RS
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 5x4 + CYA 6ZŽ:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
98495 | 1.S | K18.98495 | 1.S | 151.39 | R-RS-VYT5.02
98496 | 1.S | K18.98496 | 1.S | 1379.05 | R-RS-VYT5.02
98499 | 1.S | K18.98499 | 1.S | 2323.79 | R-RS-VYT5.02
98502 | 1.S | K18.98502 | 1.S | 6881.54 | R-RS-VYT5.02
98505 | 5.NP | K18.98505 | 5.NP | 17300 | R-RS-VYT5.02
98506 | 1.S | K18.98506 | 1.S | 16031.5 | R-RS-VYT5.02
98507 | 1.S | K18.98507 | 1.S | 950 | R-RS-VYT5.02
98657 | 5.NP | K18.98657 | 5.NP | 2480.76 | R-RS-VYT5.02
98660 | 5.NP | K18.98660 | 5.NP | 1560 | R-RS-VYT5.02
98665 | 5.NP | K18.98665 | 5.NP | 3220 | R-RS-VYT5.02
98669 | 5.NP | K18.98669 | 5.NP | 1210 | R-RS-VYT5.02
98694 | 5.NP | K18.98694 | 5.NP | 442.48 | R-RS-VYT5.02
146453 | 1.S | K18.146453 | 1.S | 151.39 | R-RS-VYT5.01
146456 | 1.S | K18.146456 | 1.S | 1379.05 | R-RS-VYT5.01
146459 | 1.S | K18.146459 | 1.S | 2323.79 | R-RS-VYT5.01
146462 | 1.S | K18.146462 | 1.S | 6956.54 | R-RS-VYT5.01
146465 | 1.S | K18.146465 | 1.S | 16031.5 | R-RS-VYT5.01
146468 | 5.NP | K18.146468 | 5.NP | 16900 | R-RS-VYT5.01
146471 | 5.NP | K18.146471 | 5.NP | 708.3 | R-RS-VYT5.01
146474 | 5.NP | K18.146474 | 5.NP | 32511.4 | R-RS-VYT5.01
146477 | 5.NP | K18.146477 | 5.NP | 1260 | R-RS-VYT5.01
146480 | 5.NP | K18.146480 | 5.NP | 1731.13 | R-RS-VYT5.01
146558 | 1.S | K18.146558 | 1.S | 950 | R-RS-VYT5.01
146561 | 5.NP mezipatro | K18.146561 | 5.NP mezipatro | 1310 | R-RS-VYT5.01
235231 | 5.NP | K18.235231 | 5.NP | 200 | R-RS-VYT5.01

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-O 7x1,5 (4)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-O 7x1,5; ElementProjectSpecificDescription: CYKY-O 7x1,5; ElementProjectSpecificIdentifier: K20; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-O 7x1,5
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:CYKY-O 7x1,5:...) | Reference | Length
116280 | K20.116280 | 1213.17
116288 | K20.116288 | 500
116305 | K20.116305 | 1400
116318 | K20.116318 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:H07RN-F 5Gx16 (5)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: H07RN-F 5Gx16; ElementProjectSpecificDescription: H07RN-F 5Gx16; ElementProjectSpecificIdentifier: K22; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: H07RN-F 5Gx16
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:H07RN-F 5Gx16:...) | In | Reference | StoreyProjectSpecificIdentifier | Length
231285 | 5.NP | K22.231285 | 5.NP | 2750
231287 | 5.NP mezipatro | K22.231287 | 5.NP mezipatro | 770.17
231288 | 5.NP mezipatro | K22.231288 | 5.NP mezipatro | 836.44
231291 | 5.NP mezipatro | K22.231291 | 5.NP mezipatro | 350
231294 | 5.NP mezipatro | K22.231294 | 5.NP mezipatro | 1550

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:Solar 6mm (96)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Solar 6mm; ElementProjectSpecificDescription: Solar 6mm; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: Solar 6mm
Pset_JunctionBoxTypeCommon - Reference: R-RDC-FVE
Pset_DistributionSystemCommon - Reference: RDC
Name (Elektroinstalační trubka bez tvarovek:Solar 6mm:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Length
104359 | Střecha | K21.104359 | String 1 | Střecha | 759.39
104378 | 5.NP mezipatro | K21.104378 | String 1 | 5.NP mezipatro | 1905
104383 | 5.NP mezipatro | K21.104383 | String 1 | 5.NP mezipatro | 837.1
104392 | 5.NP mezipatro | K21.104392 | String 1 | 5.NP mezipatro | 2235
104397 | 5.NP mezipatro | K21.104397 | String 1 | 5.NP mezipatro | 255
104401 | 5.NP mezipatro | K21.104401 | String 1 | 5.NP mezipatro | 355
104438 | 5.NP mezipatro | K21.104438 | String 1 | 5.NP mezipatro | 1755.35
104666 | Střecha | K21.104666 | String 1 | Střecha | 675.29
104711 | Střecha | K21.104711 | String 1 | Střecha | 6315.41
104748 | Střecha | K21.104748 | String 1 | Střecha | 26720
104760 | Střecha | K21.104760 | String 1 | Střecha | 6365
104770 | Střecha | K21.104770 | String 1 | Střecha | 12780
104778 | Střecha | K21.104778 | String 1 | Střecha | 1400
104788 | Střecha | K21.104788 | String 1 | Střecha | 12720
104796 | Střecha | K21.104796 | String 1 | Střecha | 1460
104806 | Střecha | K21.104806 | String 1 | Střecha | 12740
104814 | Střecha | K21.104814 | String 1 | Střecha | 600
104824 | Střecha | K21.104824 | String 1 | Střecha | 9500
104832 | Střecha | K21.104832 | String 1 | Střecha | 700
104842 | Střecha | K21.104842 | String 1 | Střecha | 3120
104850 | Střecha | K21.104850 | String 1 | Střecha | 1790
104860 | Střecha | K21.104860 | String 1 | Střecha | 26625
104868 | Střecha | K21.104868 | String 1 | Střecha | 6315.41
105227 | Střecha | K21.105227 | String 1 | Střecha | 605.36
105239 | Střecha | K21.105239 | String 1 | Střecha | 779.3
105256 | 5.NP mezipatro | K21.105256 | String 1 | 5.NP mezipatro | 856.038
105268 | 5.NP mezipatro | K21.105268 | String 1 | 5.NP mezipatro | 2205
105280 | 5.NP mezipatro | K21.105280 | String 1 | 5.NP mezipatro | 1900
105298 | 5.NP mezipatro | K21.105298 | String 1 | 5.NP mezipatro | 250
105310 | 5.NP mezipatro | K21.105310 | String 1 | 5.NP mezipatro | 370
105322 | 5.NP mezipatro | K21.105322 | String 1 | 5.NP mezipatro | 1755.35
105472 | Střecha | K21.105472 | String 1 | Střecha | 69.29
105842 | Střecha | K21.105842 | String 2 | Střecha | 749.3
105851 | Střecha | K21.105851 | String 2 | Střecha | 734.3
105860 | Střecha | K21.105860 | String 3 | Střecha | 719.3
105869 | Střecha | K21.105869 | String 3 | Střecha | 704.3
105882 | Střecha | K21.105882 | String 2 | Střecha | 605.36
105891 | Střecha | K21.105891 | String 2 | Střecha | 605.36
105900 | Střecha | K21.105900 | String 3 | Střecha | 605.36
105909 | Střecha | K21.105909 | String 3 | Střecha | 605.36
105922 | Střecha | K21.105922 | String 2 | Střecha | 6315.41
105931 | Střecha | K21.105931 | String 2 | Střecha | 6315.41
105940 | Střecha | K21.105940 | String 3 | Střecha | 6065.41
105949 | Střecha | K21.105949 | String 3 | Střecha | 1330.41
106004 | 5.NP mezipatro | K21.106004 | String 2 | 5.NP mezipatro | 856.038
106013 | 5.NP mezipatro | K21.106013 | String 2 | 5.NP mezipatro | 856.038
106022 | 5.NP mezipatro | K21.106022 | String 3 | 5.NP mezipatro | 856.039
106031 | 5.NP mezipatro | K21.106031 | String 3 | 5.NP mezipatro | 856.039
106044 | 5.NP mezipatro | K21.106044 | String 2 | 5.NP mezipatro | 1950
106053 | 5.NP mezipatro | K21.106053 | String 2 | 5.NP mezipatro | 1980
106062 | 5.NP mezipatro | K21.106062 | String 3 | 5.NP mezipatro | 2010
106071 | 5.NP mezipatro | K21.106071 | String 3 | 5.NP mezipatro | 2039.99
106084 | 5.NP mezipatro | K21.106084 | String 2 | 5.NP mezipatro | 2265
106093 | 5.NP mezipatro | K21.106093 | String 2 | 5.NP mezipatro | 2295
106102 | 5.NP mezipatro | K21.106102 | String 3 | 5.NP mezipatro | 2325
106111 | 5.NP mezipatro | K21.106111 | String 3 | 5.NP mezipatro | 2355
106124 | 5.NP mezipatro | K21.106124 | String 2 | 5.NP mezipatro | 255
106133 | 5.NP mezipatro | K21.106133 | String 2 | 5.NP mezipatro | 255
106142 | 5.NP mezipatro | K21.106142 | String 3 | 5.NP mezipatro | 255
106151 | 5.NP mezipatro | K21.106151 | String 3 | 5.NP mezipatro | 255
106164 | 5.NP mezipatro | K21.106164 | String 2 | 5.NP mezipatro | 340
106173 | 5.NP mezipatro | K21.106173 | String 2 | 5.NP mezipatro | 325
106182 | 5.NP mezipatro | K21.106182 | String 3 | 5.NP mezipatro | 310
106191 | 5.NP mezipatro | K21.106191 | String 3 | 5.NP mezipatro | 295
106230 | 5.NP mezipatro | K21.106230 | String 2 | 5.NP mezipatro | 1755.35
106239 | 5.NP mezipatro | K21.106239 | String 2 | 5.NP mezipatro | 1755.35
106248 | 5.NP mezipatro | K21.106248 | String 3 | 5.NP mezipatro | 1755.35
106257 | 5.NP mezipatro | K21.106257 | String 3 | 5.NP mezipatro | 1755.35
106426 | Střecha | K21.106426 | String 2 | Střecha | 84.29
106435 | Střecha | K21.106435 | String 2 | Střecha | 99.29
106444 | Střecha | K21.106444 | String 3 | Střecha | 114.29
106453 | Střecha | K21.106453 | String 3 | Střecha | 129.29
106530 | Střecha | K21.106530 | String 2 | Střecha | 12760
106539 | Střecha | K21.106539 | String 2 | Střecha | 14820
106625 | Střecha | K21.106625 | String 2 | Střecha | 400
106635 | Střecha | K21.106635 | String 2 | Střecha | 10600
106643 | Střecha | K21.106643 | String 2 | Střecha | 600
106653 | Střecha | K21.106653 | String 2 | Střecha | 4100
106661 | Střecha | K21.106661 | String 2 | Střecha | 600
106671 | Střecha | K21.106671 | String 2 | Střecha | 8400
106679 | Střecha | K21.106679 | String 2 | Střecha | 4500
106689 | Střecha | K21.106689 | String 2 | Střecha | 12740
106723 | Střecha | K21.106723 | String 2 | Střecha | 698.76
106779 | Střecha | K21.106779 | String 2 | Střecha | 5125
106788 | Střecha | K21.106788 | String 2 | Střecha | 700
106798 | Střecha | K21.106798 | String 2 | Střecha | 7440
106808 | Střecha | K21.106808 | String 2 | Střecha | 4816.24
107753 | Střecha | K21.107753 | String 3 | Střecha | 12640
107757 | Střecha | K21.107757 | String 3 | Střecha | 1600
107761 | Střecha | K21.107761 | String 3 | Střecha | 12575
107765 | Střecha | K21.107765 | String 3 | Střecha | 1360
107769 | Střecha | K21.107769 | String 3 | Střecha | 12580
107773 | Střecha | K21.107773 | String 3 | Střecha | 640
107777 | Střecha | K21.107777 | String 3 | Střecha | 9400
107781 | Střecha | K21.107781 | String 3 | Střecha | 750
107785 | Střecha | K21.107785 | String 3 | Střecha | 3130
