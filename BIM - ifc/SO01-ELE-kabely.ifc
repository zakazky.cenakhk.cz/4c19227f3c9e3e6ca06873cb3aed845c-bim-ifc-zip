Properties of the parts of a building model (IFC4), part 3 of 7

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x1,5 (1380)
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
129575 | 1.NP | K09.129575 | 1.NP | 78.54 | R-RS-LM1.13
129652 | 1.NP mezipatro | K09.129652 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
129655 | 1.NP mezipatro | K09.129655 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
129658 | 1.NP mezipatro | K09.129658 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
129675 | 1.NP mezipatro | K09.129675 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
129708 | 1.NP mezipatro | K09.129708 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
129711 | 1.NP mezipatro | K09.129711 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
129738 | 1.NP mezipatro | K09.129738 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
129741 | 1.NP mezipatro | K09.129741 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
129830 | 1.NP mezipatro | K09.129830 | 1.NP mezipatro | 39.27 | R-RS-LM1.05
129835 | 1.NP mezipatro | K09.129835 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
129838 | 1.NP mezipatro | K09.129838 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
129945 | 1.NP mezipatro | K09.129945 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
129950 | 1.NP mezipatro | K09.129950 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
129953 | 1.NP mezipatro | K09.129953 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130171 | 1.NP mezipatro | K09.130171 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130196 | 1.NP mezipatro | K09.130196 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130204 | 1.NP mezipatro | K09.130204 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130212 | 1.NP mezipatro | K09.130212 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130219 | 1.NP mezipatro | K09.130219 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130222 | 1.NP mezipatro | K09.130222 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
130415 | 1.S mezipatro | K09.130415 | 1.S mezipatro | 78.54 | R-RS-LM0.13
130421 | 1.S mezipatro | K09.130421 | 1.S mezipatro | 78.54 | R-RS-LM0.13
130424 | 1.S mezipatro | K09.130424 | 1.S mezipatro | 78.54 | R-RS-LM0.13
130462 | 1.S mezipatro | K09.130462 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130465 | 1.S mezipatro | K09.130465 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130547 | 1.S mezipatro | K09.130547 | 1.S mezipatro | 39.27 | R-RS-LM0.12
130552 | 1.S mezipatro | K09.130552 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130555 | 1.S mezipatro | K09.130555 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130653 | 1.S mezipatro | K09.130653 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130659 | 1.S mezipatro | K09.130659 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130662 | 1.S mezipatro | K09.130662 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130820 | 1.S mezipatro | K09.130820 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130828 | 1.S mezipatro | K09.130828 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130831 | 1.S mezipatro | K09.130831 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130901 | 1.S mezipatro | K09.130901 | 1.S mezipatro | 78.54 | R-RS-LM0.12
130904 | 1.S mezipatro | K09.130904 | 1.S mezipatro | 78.54 | R-RS-LM0.12
131056 | 1.S | K09.131056 | 1.S | 78.54 | R-RS-LM0.11
131079 | 1.S | K09.131079 | 1.S | 78.54 | R-RS-LM0.11
131126 | 1.S | K09.131126 | 1.S | 78.54 | R-RS-LM0.10
131129 | 1.S | K09.131129 | 1.S | 78.54 | R-RS-LM0.10
131353 | 1.S | K09.131353 | 1.S | 78.54 | R-RS-LM0.10
131356 | 1.S | K09.131356 | 1.S | 78.54 | R-RS-LM0.10
131512 | 1.S | K09.131512 | 1.S | 78.54 | R-RS-LM0.10
131515 | 1.S | K09.131515 | 1.S | 78.54 | R-RS-LM0.10
131572 | 1.S | K09.131572 | 1.S | 78.54 | R-RS-LM0.10
131574 | 1.S | K09.131574 | 1.S | 8.53 | R-RS-LM0.10
131608 | 1.S | K09.131608 | 1.S | 78.54 | R-RS-LM0.10
131611 | 1.S | K09.131611 | 1.S | 78.54 | R-RS-LM0.10
131765 | 1.S | K09.131765 | 1.S | 78.54 | R-RS-LM0.09
131825 | 1.S mezipatro | K09.131825 | 1.S mezipatro | 78.54 | R-RS-LM0.08/C
131851 | 1.S | K09.131851 | 1.S | 78.54 | R-RS-LM0.08/A
131864 | 1.S | K09.131864 | 1.S | 78.54 | R-RS-LM0.08/A
131885 | 1.S | K09.131885 | 1.S | 78.54 | R-RS-LM0.06
131897 | 1.S | K09.131897 | 1.S | 78.54 | R-RS-LM0.06
131984 | 1.S | K09.131984 | 1.S | 78.54 | R-RS-LM0.02
131986 | 1.S | K09.131986 | 1.S | 39.27 | R-RS-LM0.02
131991 | 1.S | K09.131991 | 1.S | 78.54 | R-RS-LM0.02
131994 | 1.S | K09.131994 | 1.S | 78.54 | R-RS-LM0.02
141856 | 1.S | K09.141856 | 1.S | 74.39 | R-RS-LM0.02
141859 | 1.S | K09.141859 | 1.S | 78.54 | R-RS-LM0.02
143164 | 1.S | K09.143164 | 1.S | 74.39 | R-RS-LM0.03
143167 | 1.S | K09.143167 | 1.S | 78.54 | R-RS-LM0.03
143254 | 1.S | K09.143254 | 1.S | 74.39 | R-RS-LM0.04
143257 | 1.S | K09.143257 | 1.S | 78.54 | R-RS-LM0.04
143330 | 1.S | K09.143330 | 1.S | 74.39 | R-RS-LM0.05
143333 | 1.S | K09.143333 | 1.S | 78.54 | R-RS-LM0.05
143348 | 1.S | K09.143348 | 1.S | 74.39 | R-RS-LM0.06
143351 | 1.S | K09.143351 | 1.S | 78.54 | R-RS-LM0.06
143441 | 1.S | K09.143441 | 1.S | 74.39 | R-RS-LM0.07
143444 | 1.S | K09.143444 | 1.S | 78.54 | R-RS-LM0.07
143540 | 1.S | K09.143540 | 1.S | 74.39 | R-RS-LM0.08/A
143543 | 1.S | K09.143543 | 1.S | 78.54 | R-RS-LM0.08/A
143585 | 1.S | K09.143585 | 1.S | 74.39 | R-RS-LM0.08/B
143588 | 1.S | K09.143588 | 1.S | 78.54 | R-RS-LM0.08/B
143675 | 1.S | K09.143675 | 1.S | 73.56 | R-RS-LM0.08/C
143677 | 1.S | K09.143677 | 1.S | 78.54 | R-RS-LM0.08/C
143697 | 1.S | K09.143697 | 1.S | 73.56 | R-RS-LM0.09
143700 | 1.S | K09.143700 | 1.S | 78.54 | R-RS-LM0.09
193182 | 1.S | K09.193182 | 1.S | 78.54 | R-RS-VZT.01
193184 | 1.S | K09.193184 | 1.S | 78.54 | R-RS-VZT.01
193243 | 1.S | K09.193243 | 1.S | 78.54 | R-RS-VZT.01
193246 | 1.S | K09.193246 | 1.S | 78.54 | R-RS-VZT.01
193302 | 1.S | K09.193302 | 1.S | 78.54 | R-RS-VZT.01
193305 | 1.S | K09.193305 | 1.S | 78.54 | R-RS-VZT.01
193444 | 1.S | K09.193444 | 1.S | 78.54 | R-RS-VZT.01
193447 | 1.S | K09.193447 | 1.S | 78.54 | R-RS-VZT.01
193512 | 1.S | K09.193512 | 1.S | 78.54 | R-RS-VZT.01
193517 | 1.S | K09.193517 | 1.S | 78.54 | R-RS-VZT.01
193520 | 1.S | K09.193520 | 1.S | 78.54 | R-RS-VZT.01
193647 | 1.S | K09.193647 | 1.S | 78.54 | R-RS-VZT.01
193650 | 1.S | K09.193650 | 1.S | 78.54 | R-RS-VZT.01
193659 | 1.S | K09.193659 | 1.S | 78.54 | R-RS-VZT.01
200234 | 1.S | K09.200234 | 1.S | 78.54 | R-RS-LM0.09
201221 | 1.S mezipatro | K09.201221 | 1.S mezipatro | 78.54 | R-RS-LM1.02
201224 | 1.S mezipatro | K09.201224 | 1.S mezipatro | 78.54 | R-RS-LM1.02
201622 | 4.NP | K09.201622 | 4.NP | 78.54 | R-RS-LM1.02
201803 | 3.NP mezipatro | K09.201803 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
201806 | 3.NP mezipatro | K09.201806 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
201970 | 2.NP mezipatro | K09.201970 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
202047 | 1.NP mezipatro | K09.202047 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
202401 | 3.NP | K09.202401 | 3.NP | 30.025 | R-RS-LM1.01
202410 | 2.NP mezipatro | K09.202410 | 2.NP mezipatro | 30.025 | R-RS-LM1.01
202937 | 3.NP mezipatro | K09.202937 | 3.NP mezipatro | 30.025 | R-RS-LM1.01
202941 | 4.NP | K09.202941 | 4.NP | 30.025 | R-RS-LM1.01
203010 | 2.NP | K09.203010 | 2.NP | 30.025 | R-RS-LM1.01
203014 | 1.NP mezipatro | K09.203014 | 1.NP mezipatro | 30.025 | R-RS-LM1.01
203017 | 1.NP mezipatro | K09.203017 | 1.NP mezipatro | 78.54 | R-RS-LM1.01
203067 | 1.S mezipatro | K09.203067 | 1.S mezipatro | 30.025 | R-RS-LM1.01
203071 | 1.NP | K09.203071 | 1.NP | 30.025 | R-RS-LM1.01
203324 | 1.S | K09.203324 | 1.S | 30.025 | R-RS-LM1.01
203407 | 1.S | K09.203407 | 1.S | 78.54 | R-RS-LM1.01
203451 | 1.S | K09.203451 | 1.S | 78.54 | R-RS-LM1.01
203461 | 1.S | K09.203461 | 1.S | 78.54 | R-RS-LM1.01
203685 | 4.NP mezipatro | K09.203685 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
203727 | 5.NP | K09.203727 | 5.NP | 78.54 | R-RS-LM1.01
203739 | 4.NP mezipatro | K09.203739 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
204250 | 1.S mezipatro | K09.204250 | 1.S mezipatro | 78.54 | R-RS-LM0.13
204253 | 1.S mezipatro | K09.204253 | 1.S mezipatro | 78.54 | R-RS-LM0.13
204284 | 2.NP mezipatro | K09.204284 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
205837 | 1.S | K09.205837 | 1.S | 78.54 | R-RS-EZS
205840 | 1.S | K09.205840 | 1.S | 78.54 | R-RS-EZS
205843 | 1.S | K09.205843 | 1.S | 78.54 | R-RS-EZS
205848 | 1.S | K09.205848 | 1.S | 78.54 | R-RS-EZS
205851 | 1.S | K09.205851 | 1.S | 78.54 | R-RS-EZS
205854 | 1.S | K09.205854 | 1.S | 78.54 | R-RS-EZS
205856 | 1.S | K09.205856 | 1.S | 78.54 | R-RS-EZS
205938 | 1.S | K09.205938 | 1.S | 78.54 | R-RS-EZS
207900 | 1.S | K09.207900 | 1.S | 12.22 | R-RS-LM0.11
207902 | 1.S | K09.207902 | 1.S | 78.54 | R-RS-LM0.11
230552 | 1.S | K09.230552 | 1.S | 78.54 | R-RS-LM0.09
230554 | 1.S | K09.230554 | 1.S | 78.54 | R-RS-LM0.09
230556 | 1.S | K09.230556 | 1.S | 78.54 | R-RS-LM0.09
231981 | 5.NP | K09.231981 | 5.NP | 78.54 | R-RS-LM5.04
231993 | 5.NP mezipatro | K09.231993 | 5.NP mezipatro | 78.54 | R-RS-LM5.04
231995 | 5.NP | K09.231995 | 5.NP | 78.54 | R-RS-LM5.04
232000 | 5.NP | K09.232000 | 5.NP | 78.54 | R-RS-LM5.04
234783 | 5.NP | K09.234783 | 5.NP | 78.54 | R-RS-LM5.13
234903 | 5.NP | K09.234903 | 5.NP | 78.54 | R-RS-LM5.03
234906 | 5.NP | K09.234906 | 5.NP | 78.54 | R-RS-LM5.03
234942 | 5.NP | K09.234942 | 5.NP | 78.54 | R-RS-LM5.14
235060 | 5.NP | K09.235060 | 5.NP | 78.54 | R-RS-LM5.04

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x120+70 + CYA25ZŽ (3)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificDescription: CYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificIdentifier: K13; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x120+70 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x120+70 + CYA25ZŽ:...) | Reference
115179 | K13.115179
115489 | K13.115489
115502 | K13.115502

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x2,5 (207)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x2,5; ElementProjectSpecificDescription: CYKY-J 3x2,5; ElementProjectSpecificIdentifier: K10; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x2,5
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x2,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
81245 | 1.S | K10.81245 | 1.S | 78.54 | R-RS-Z0.02
81436 | 1.S | K10.81436 | 1.S | 78.54 | R-RS-Z0.02
81484 | 1.S | K10.81484 | 1.S | 78.54 | R-RS-Z0.02
81511 | 1.S | K10.81511 | 1.S | 78.54 | R-RS-Z0.02
81557 | 1.S | K10.81557 | 1.S | 78.54 | R-RS-Z0.02
81581 | 1.S | K10.81581 | 1.S | 78.54 | R-RS-Z0.02
81583 | 1.S | K10.81583 | 1.S | 39.27 | R-RS-Z0.02
81585 | 1.S | K10.81585 | 1.S | 39.27 | R-RS-Z0.02
81639 | 1.S | K10.81639 | 1.S | 78.54 | R-RS-Z0.03
81642 | 1.S | K10.81642 | 1.S | 78.54 | R-RS-Z0.03
81645 | 1.S | K10.81645 | 1.S | 78.54 | R-RS-Z0.03
81649 | 1.S | K10.81649 | 1.S | 78.54 | R-RS-Z0.03
81825 | 1.S | K10.81825 | 1.S | 78.54 | R-RS-Z0.03
81828 | 1.S | K10.81828 | 1.S | 39.27 | R-RS-Z0.03
81830 | 1.S | K10.81830 | 1.S | 39.27 | R-RS-Z0.03
81832 | 1.S | K10.81832 | 1.S | 78.54 | R-RS-Z0.03
81841 | 1.S | K10.81841 | 1.S | 78.54 | R-RS-Z0.03
81900 | 1.S | K10.81900 | 1.S | 78.54 | R-RS-Z0.04
81903 | 1.S | K10.81903 | 1.S | 78.54 | R-RS-Z0.04
81906 | 1.S | K10.81906 | 1.S | 78.54 | R-RS-Z0.04
81909 | 1.S | K10.81909 | 1.S | 78.54 | R-RS-Z0.04
81924 | 1.S | K10.81924 | 1.S | 78.54 | R-RS-Z0.04
81978 | 1.S | K10.81978 | 1.S | 78.54 | R-RS-Z0.04
81981 | 1.S | K10.81981 | 1.S | 39.27 | R-RS-Z0.04
81983 | 1.S | K10.81983 | 1.S | 39.27 | R-RS-Z0.04
81985 | 1.S | K10.81985 | 1.S | 78.54 | R-RS-Z0.04
82146 | 1.S | K10.82146 | 1.S | 78.54 | R-RS-Z0.05
82161 | 1.S | K10.82161 | 1.S | 78.54 | R-RS-Z0.05
82227 | 1.S | K10.82227 | 1.S | 78.54 | R-RS-Z0.05
82230 | 1.S | K10.82230 | 1.S | 39.27 | R-RS-Z0.05
82232 | 1.S | K10.82232 | 1.S | 39.27 | R-RS-Z0.05
82279 | 1.S | K10.82279 | 1.S | 78.54 | R-RS-Z0.06
82282 | 1.S | K10.82282 | 1.S | 78.54 | R-RS-Z0.06
82286 | 1.S | K10.82286 | 1.S | 78.54 | R-RS-Z0.06
82288 | 1.S | K10.82288 | 1.S | 39.27 | R-RS-Z0.06
82290 | 1.S | K10.82290 | 1.S | 39.27 | R-RS-Z0.06
82340 | 1.S | K10.82340 | 1.S | 78.54 | R-RS-Z0.06
82352 | 1.S | K10.82352 | 1.S | 78.54 | R-RS-Z0.05
82400 | 1.S | K10.82400 | 1.S | 78.54 | R-RS-Z0.07
82403 | 1.S | K10.82403 | 1.S | 78.54 | R-RS-Z0.07
82406 | 1.S | K10.82406 | 1.S | 78.54 | R-RS-Z0.07
82409 | 1.S | K10.82409 | 1.S | 78.54 | R-RS-Z0.07
82509 | 1.S | K10.82509 | 1.S | 78.54 | R-RS-Z0.07
82523 | 1.S | K10.82523 | 1.S | 78.54 | R-RS-Z0.07
82565 | 1.S | K10.82565 | 1.S | 78.54 | R-RS-Z0.07
82637 | 1.S | K10.82637 | 1.S | 78.54 | R-RS-Z0.07
82639 | 1.S | K10.82639 | 1.S | 39.27 | R-RS-Z0.07
82641 | 1.S | K10.82641 | 1.S | 39.27 | R-RS-Z0.07
84177 | 1.S | K10.84177 | 1.S | 78.54 | R-RS-Z0.08
84180 | 1.S | K10.84180 | 1.S | 78.54 | R-RS-Z0.08
84183 | 1.S | K10.84183 | 1.S | 78.54 | R-RS-Z0.08
84186 | 1.S | K10.84186 | 1.S | 78.54 | R-RS-Z0.08
84189 | 1.S | K10.84189 | 1.S | 78.54 | R-RS-Z0.08
84250 | 1.S | K10.84250 | 1.S | 78.54 | R-RS-Z0.08
85174 | 1.S | K10.85174 | 1.S | 78.54 | R-RS-Z0.09
85177 | 1.S | K10.85177 | 1.S | 78.54 | R-RS-Z0.09
85180 | 1.S | K10.85180 | 1.S | 78.54 | R-RS-Z0.09
85183 | 1.S | K10.85183 | 1.S | 78.54 | R-RS-Z0.09
85190 | 1.S | K10.85190 | 1.S | 78.54 | R-RS-Z0.09
85194 | 1.S | K10.85194 | 1.S | 78.54 | R-RS-Z0.09
85196 | 1.S | K10.85196 | 1.S | 39.27 | R-RS-Z0.09
85198 | 1.S | K10.85198 | 1.S | 39.27 | R-RS-Z0.09
85317 | 1.S | K10.85317 | 1.S | 78.54 | R-RS-Z0.09
85340 | 1.S | K10.85340 | 1.S | 78.54 | R-RS-Z0.09
85418 | 1.S | K10.85418 | 1.S | 78.54 | R-RS-Z0.10
85421 | 1.S | K10.85421 | 1.S | 78.54 | R-RS-Z0.10
85424 | 1.S | K10.85424 | 1.S | 78.54 | R-RS-Z0.10
85427 | 1.S | K10.85427 | 1.S | 78.54 | R-RS-Z0.10
85435 | 1.S | K10.85435 | 1.S | 78.54 | R-RS-Z0.10
85440 | 1.S | K10.85440 | 1.S | 78.54 | R-RS-Z0.10
85444 | 1.S | K10.85444 | 1.S | 78.54 | R-RS-Z0.10
85446 | 1.S | K10.85446 | 1.S | 39.27 | R-RS-Z0.10
85551 | 1.S | K10.85551 | 1.S | 78.54 | R-RS-Z0.10
85553 | 1.S | K10.85553 | 1.S | 39.27 | R-RS-Z0.10
85596 | 1.S | K10.85596 | 1.S | 78.54 | R-RS-Z0.11
85599 | 1.S | K10.85599 | 1.S | 78.54 | R-RS-Z0.11
85602 | 1.S | K10.85602 | 1.S | 78.54 | R-RS-Z0.11
85605 | 1.S | K10.85605 | 1.S | 78.54 | R-RS-Z0.11
85608 | 1.S | K10.85608 | 1.S | 78.54 | R-RS-Z0.11
85714 | 1.S | K10.85714 | 1.S | 78.54 | R-RS-Z0.11
85741 | 1.S | K10.85741 | 1.S | 78.54 | R-RS-Z0.11
85948 | 1.S | K10.85948 | 1.S | 78.54 | R-RS-Z0.12
85951 | 1.S | K10.85951 | 1.S | 78.54 | R-RS-Z0.12
85954 | 1.S | K10.85954 | 1.S | 78.54 | R-RS-Z0.12
85957 | 1.S | K10.85957 | 1.S | 78.54 | R-RS-Z0.12
85960 | 1.S | K10.85960 | 1.S | 78.54 | R-RS-Z0.12
85975 | 1.S | K10.85975 | 1.S | 78.54 | R-RS-Z0.12
91455 | 1.S | K10.91455 | 1.S | 78.54 | R-RS-Z0.20
91458 | 1.S | K10.91458 | 1.S | 78.54 | R-RS-Z0.20
91461 | 1.S | K10.91461 | 1.S | 78.54 | R-RS-Z0.20
91464 | 1.S | K10.91464 | 1.S | 78.54 | R-RS-Z0.20
91523 | 1.S | K10.91523 | 1.S | 78.54 | R-RS-Z0.20
91525 | 1.S | K10.91525 | 1.S | 39.27 | R-RS-Z0.20
91527 | 1.S | K10.91527 | 1.S | 39.27 | R-RS-Z0.20
91529 | 1.S | K10.91529 | 1.S | 78.54 | R-RS-Z0.20
91543 | 1.S | K10.91543 | 1.S | 78.54 | R-RS-Z0.20
91548 | 1.S | K10.91548 | 1.S | 78.54 | R-RS-Z0.21
91551 | 1.S | K10.91551 | 1.S | 78.54 | R-RS-Z0.21
91554 | 1.S | K10.91554 | 1.S | 78.54 | R-RS-Z0.21
91563 | 1.S | K10.91563 | 1.S | 78.54 | R-RS-Z0.21
91565 | 1.S | K10.91565 | 1.S | 39.27 | R-RS-Z0.21
91567 | 1.S | K10.91567 | 1.S | 39.27 | R-RS-Z0.21
91569 | 1.S | K10.91569 | 1.S | 78.54 | R-RS-Z0.21
91704 | 1.S | K10.91704 | 1.S | 78.54 | R-RS-ZTI-4-01
91707 | 1.S | K10.91707 | 1.S | 78.54 | R-RS-ZTI-4-01
91710 | 1.S | K10.91710 | 1.S | 78.54 | R-RS-ZTI-4-01
91714 | 1.S | K10.91714 | 1.S | 78.54 | R-RS-ZTI-4-01
91716 | 1.S | K10.91716 | 1.S | 78.54 | R-RS-ZTI-4-01
91787 | Střecha | K10.91787 | Střecha | 78.54 | R-RS-ZTI-4-01
91791 | Střecha | K10.91791 | Střecha | 78.54 | R-RS-ZTI-4-01
91800 | Střecha | K10.91800 | Střecha | 78.54 | R-RS-ZTI-4-01
91802 | 1.S | K10.91802 | 1.S | 78.54 | R-RS-ZTI-4-01
91835 | 1.S | K10.91835 | 1.S | 78.54 | R-RS-ZTI-4-02
91838 | 1.S | K10.91838 | 1.S | 78.54 | R-RS-ZTI-4-02
91841 | 1.S | K10.91841 | 1.S | 78.54 | R-RS-ZTI-4-02
91845 | 1.S | K10.91845 | 1.S | 78.54 | R-RS-ZTI-4-02
91847 | 1.S | K10.91847 | 1.S | 78.54 | R-RS-ZTI-4-02
91849 | 1.S | K10.91849 | 1.S | 78.54 | R-RS-ZTI-4-02
91954 | 4.NP | K10.91954 | 4.NP | 78.54 | R-RS-ZTI-4-02
91959 | 4.NP mezipatro | K10.91959 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-02
91961 | 4.NP mezipatro | K10.91961 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-02
91967 | 4.NP | K10.91967 | 4.NP | 78.54 | R-RS-ZTI-4-02
92000 | 4.NP mezipatro | K10.92000 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-02
92955 | 1.S | K10.92955 | 1.S | 78.54 | R-RS-ZTI-4-03
92958 | 1.S | K10.92958 | 1.S | 78.54 | R-RS-ZTI-4-03
92961 | 1.S | K10.92961 | 1.S | 78.54 | R-RS-ZTI-4-03
92965 | 1.S | K10.92965 | 1.S | 78.54 | R-RS-ZTI-4-03
92967 | 1.S | K10.92967 | 1.S | 78.54 | R-RS-ZTI-4-03
92969 | 1.S | K10.92969 | 1.S | 78.54 | R-RS-ZTI-4-03
93065 | 4.NP mezipatro | K10.93065 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-03
93072 | 4.NP mezipatro | K10.93072 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-03
93074 | 4.NP mezipatro | K10.93074 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-03
93083 | 4.NP mezipatro | K10.93083 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-03
115448 | 1.S | K10.115448 | 1.S | 78.54 | R-RS-Z0.21
200489 | 1.S | K10.200489 | 1.S | 78.54 | R-RS-Z0.08
200528 | 1.S | K10.200528 | 1.S | 78.54 | R-RS-Z0.08
200531 | 1.S | K10.200531 | 1.S | 78.54 | R-RS-Z0.08
200679 | 1.S | K10.200679 | 1.S | 78.54 | R-RS-Z0.12
200684 | 1.S | K10.200684 | 1.S | 78.54 | R-RS-Z0.12
200687 | 1.S | K10.200687 | 1.S | 78.54 | R-RS-Z0.12
200752 | 1.S | K10.200752 | 1.S | 78.54 | R-RS-Z0.12
200755 | 1.S | K10.200755 | 1.S | 78.54 | R-RS-Z0.12
200757 | 1.S | K10.200757 | 1.S | 78.54 | R-RS-Z0.12
205145 | 1.S | K10.205145 | 1.S | 78.54 | R-RS-Z0.21
205147 | 1.S | K10.205147 | 1.S | 78.54 | R-RS-Z0.21
205243 | 1.S | K10.205243 | 1.S | 78.54 | R-RS-Z0.23
205246 | 1.S | K10.205246 | 1.S | 78.54 | R-RS-Z0.23
205249 | 1.S | K10.205249 | 1.S | 78.54 | R-RS-Z0.23
205256 | 1.S | K10.205256 | 1.S | 78.54 | R-RS-Z0.23
205258 | 1.S | K10.205258 | 1.S | 39.27 | R-RS-Z0.23
205260 | 1.S | K10.205260 | 1.S | 39.27 | R-RS-Z0.23
205262 | 1.S | K10.205262 | 1.S | 78.54 | R-RS-Z0.23
205265 | 1.S | K10.205265 | 1.S | 78.54 | R-RS-Z0.23
205270 | 1.S | K10.205270 | 1.S | 78.54 | R-RS-Z0.23
205707 | 1.S | K10.205707 | 1.S | 78.54 | R-RS-Z0-CCTV
205710 | 1.S | K10.205710 | 1.S | 78.54 | R-RS-Z0-CCTV
205713 | 1.S | K10.205713 | 1.S | 78.54 | R-RS-Z0-CCTV
205718 | 1.S | K10.205718 | 1.S | 78.54 | R-RS-Z0-CCTV
205721 | 1.S | K10.205721 | 1.S | 78.54 | R-RS-Z0-CCTV
205724 | 1.S | K10.205724 | 1.S | 78.54 | R-RS-Z0-CCTV
205726 | 1.S | K10.205726 | 1.S | 78.54 | R-RS-Z0-CCTV
205728 | 1.S | K10.205728 | 1.S | 78.54 | R-RS-Z0-CCTV
205989 | 1.S | K10.205989 | 1.S | 78.54 | R-RS-Z0.24
205992 | 1.S | K10.205992 | 1.S | 78.54 | R-RS-Z0.24
205995 | 1.S | K10.205995 | 1.S | 78.54 | R-RS-Z0.24
205998 | 1.S | K10.205998 | 1.S | 78.54 | R-RS-Z0.24
206001 | 1.S | K10.206001 | 1.S | 78.54 | R-RS-Z0.24
206004 | 1.S | K10.206004 | 1.S | 78.54 | R-RS-Z0.24
206007 | 1.S | K10.206007 | 1.S | 78.54 | R-RS-Z0.24
206096 | 1.S | K10.206096 | 1.S | 78.54 | R-RS-Z0.24
206124 | 1.S | K10.206124 | 1.S | 78.54 | R-RS-Z0.24
206181 | 1.S | K10.206181 | 1.S | 78.54 | R-RS-Z0.25
206184 | 1.S | K10.206184 | 1.S | 78.54 | R-RS-Z0.25
206187 | 1.S | K10.206187 | 1.S | 78.54 | R-RS-Z0.25
206190 | 1.S | K10.206190 | 1.S | 78.54 | R-RS-Z0.25
206193 | 1.S | K10.206193 | 1.S | 78.54 | R-RS-Z0.25
206196 | 1.S | K10.206196 | 1.S | 78.54 | R-RS-Z0.25
206199 | 1.S | K10.206199 | 1.S | 78.54 | R-RS-Z0.25
206203 | 1.S | K10.206203 | 1.S | 78.54 | R-RS-Z0.25
206206 | 1.S | K10.206206 | 1.S | 78.54 | R-RS-Z0.25
206564 | 1.S | K10.206564 | 1.S | 78.54 | R-RS-LM-FAS-01
206570 | 1.S | K10.206570 | 1.S | 78.54 | R-RS-LM-FAS-01
206577 | 1.S | K10.206577 | 1.S | 78.54 | R-RS-LM-FAS-01
206579 | 1.S | K10.206579 | 1.S | 39.27 | R-RS-LM-FAS-01
206581 | 1.S | K10.206581 | 1.S | 39.27 | R-RS-LM-FAS-01
206586 | 1.S | K10.206586 | 1.S | 78.54 | R-RS-LM-FAS-01
206696 | 1.S | K10.206696 | 1.S | 78.54 | R-RS-LM-FAS-01
206777 | 1.S | K10.206777 | 1.S | 78.54 | R-RS-LM-FAS-01
206851 | 1.S | K10.206851 | 1.S | 78.54 | R-RS-LM-FAS-01
207050 | 1.S | K10.207050 | 1.S | 78.54 | R-RS-Z0.02
207094 | 1.S | K10.207094 | 1.S | 78.54 | R-RS-Z0.03
207104 | 1.S | K10.207104 | 1.S | 78.54 | R-RS-Z0.03
230363 | 4.NP mezipatro | K10.230363 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-02
230365 | 4.NP mezipatro | K10.230365 | 4.NP mezipatro | 78.54 | R-RS-ZTI-4-02
230445 | 4.NP | K10.230445 | 4.NP | 78.54 | R-RS-ZTI-4-02
230523 | 1.S | K10.230523 | 1.S | 78.54 | R-RS-Z0.08
230525 | 1.S | K10.230525 | 1.S | 78.54 | R-RS-Z0.08
230527 | 1.S | K10.230527 | 1.S | 78.54 | R-RS-Z0.08
232544 | 1.S | K10.232544 | 1.S | 78.54 | R-RS-Z5.01
232547 | 1.S | K10.232547 | 1.S | 78.54 | R-RS-Z5.01
232550 | 1.S | K10.232550 | 1.S | 78.54 | R-RS-Z5.01
232553 | 1.S | K10.232553 | 1.S | 78.54 | R-RS-Z5.01
232779 | 1.S | K10.232779 | 1.S | 78.54 | R-RS-Z5.01
232781 | 1.S | K10.232781 | 1.S | 78.54 | R-RS-Z5.01
233089 | 5.NP | K10.233089 | 5.NP | 78.54 | R-RS-Z5.01
233112 | 5.NP | K10.233112 | 5.NP | 78.54 | R-RS-Z5.01
233115 | 5.NP | K10.233115 | 5.NP | 78.54 | R-RS-Z5.01

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x2,5 + CY16 (8)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x2,5 + CY16; ElementProjectSpecificDescription: CYKY-J 3x2,5 + CY16; ElementProjectSpecificIdentifier: K11; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x2,5 + CY16
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 78.54
Pset_JunctionBoxTypeCommon - Reference: R-RS-Z0-RACK
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x2,5 + CY16:...) | Reference
205554 | K11.205554
205557 | K11.205557
205560 | K11.205560
205573 | K11.205573
205576 | K11.205576
205687 | K11.205687
205690 | K11.205690
205692 | K11.205692

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x2,5+CYA6ZŽ (71)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x2,5+CYA6ZŽ; ElementProjectSpecificDescription: CYKY-J 3x2,5+CYA6ZŽ; ElementProjectSpecificIdentifier: K12; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x2,5+CYA6ZŽ
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x2,5+CYA6ZŽ:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
96731 | 1.S | K12.96731 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
96734 | 1.S | K12.96734 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
96737 | 1.S | K12.96737 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
96741 | 1.S | K12.96741 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
96743 | 1.S | K12.96743 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
96745 | 1.S | K12.96745 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
96909 | 5.NP mezipatro | K12.96909 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
97510 | 1.S | K12.97510 | 1.S | 78.54 | R-RS-VZT-ACC-01
97513 | 1.S | K12.97513 | 1.S | 78.54 | R-RS-VZT-ACC-01
97516 | 1.S | K12.97516 | 1.S | 78.54 | R-RS-VZT-ACC-01
97520 | 1.S | K12.97520 | 1.S | 78.54 | R-RS-VZT-ACC-01
97522 | 1.S | K12.97522 | 1.S | 78.54 | R-RS-VZT-ACC-01
97744 | 1.S | K12.97744 | 1.S | 78.54 | R-RS-VZT-ACC-01
97746 | 1.S | K12.97746 | 1.S | 39.27 | R-RS-VZT-ACC-01
97789 | 1.S | K12.97789 | 1.S | 78.54 | R-RS-VZT-ACC-01
97799 | 1.S | K12.97799 | 1.S | 78.54 | R-RS-VZT-ACC-01
97810 | 1.S | K12.97810 | 1.S | 78.54 | R-RS-VZT-ACC-01
97869 | 1.S | K12.97869 | 1.S | 78.54 | R-RS-VZT-ACC-01
97871 | 1.S | K12.97871 | 1.S | 39.27 | R-RS-VZT-ACC-01
97873 | 1.S | K12.97873 | 1.S | 39.27 | R-RS-VZT-ACC-01
97901 | 1.S | K12.97901 | 1.S | 78.54 | R-RS-VZT-ACC-01
97904 | 1.S | K12.97904 | 1.S | 78.54 | R-RS-VZT-ACC-01
97929 | 1.S | K12.97929 | 1.S | 78.54 | R-RS-VZT-ACC-01
97955 | 1.S | K12.97955 | 1.S | 78.54 | R-RS-VZT-ACC-01
97958 | 1.S | K12.97958 | 1.S | 39.27 | R-RS-VZT-ACC-01
97997 | 1.S | K12.97997 | 1.S | 78.54 | R-RS-VZT-ACC-01
98004 | 1.S | K12.98004 | 1.S | 78.54 | R-RS-VZT-ACC-01
98014 | 1.S | K12.98014 | 1.S | 78.54 | R-RS-VZT-ACC-01
98025 | 1.S | K12.98025 | 1.S | 78.54 | R-RS-VZT-ACC-01
98071 | 1.S | K12.98071 | 1.S | 78.54 | R-RS-VZT-ACC-01
98081 | 1.S | K12.98081 | 1.S | 78.54 | R-RS-VZT-ACC-01
98086 | 1.S | K12.98086 | 1.S | 78.54 | R-RS-VZT-ACC-01
98092 | 1.S | K12.98092 | 1.S | 78.54 | R-RS-VZT-ACC-01
98131 | 1.S | K12.98131 | 1.S | 78.54 | R-RS-VZT-ACC-01
98138 | 1.S | K12.98138 | 1.S | 78.54 | R-RS-VZT-ACC-01
98148 | 1.S | K12.98148 | 1.S | 78.54 | R-RS-VZT-ACC-01
98159 | 1.S | K12.98159 | 1.S | 78.54 | R-RS-VZT-ACC-01
98216 | 1.S | K12.98216 | 1.S | 78.54 | R-RS-VZT-ACC-01
98218 | 1.S | K12.98218 | 1.S | 78.54 | R-RS-VZT-ACC-01
98221 | 1.S | K12.98221 | 1.S | 78.54 | R-RS-VZT-ACC-01
98325 | 1.S | K12.98325 | 1.S | 78.54 | R-RS-VZT-ACC-01
98328 | 1.S | K12.98328 | 1.S | 39.27 | R-RS-VZT-ACC-01
98330 | 1.S | K12.98330 | 1.S | 39.27 | R-RS-VZT-ACC-01
98332 | 1.S | K12.98332 | 1.S | 78.54 | R-RS-VZT-ACC-01
98345 | 1.S | K12.98345 | 1.S | 78.54 | R-RS-VZT-ACC-01
98348 | 1.S | K12.98348 | 1.S | 39.27 | R-RS-VZT-ACC-01
98350 | 1.S | K12.98350 | 1.S | 39.27 | R-RS-VZT-ACC-01
98352 | 1.S | K12.98352 | 1.S | 78.54 | R-RS-VZT-ACC-01
98365 | 1.S | K12.98365 | 1.S | 78.54 | R-RS-VZT-ACC-01
98368 | 1.S | K12.98368 | 1.S | 39.27 | R-RS-VZT-ACC-01
98370 | 1.S | K12.98370 | 1.S | 39.27 | R-RS-VZT-ACC-01
98372 | 1.S | K12.98372 | 1.S | 78.54 | R-RS-VZT-ACC-01
233715 | 5.NP mezipatro | K12.233715 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
233718 | 5.NP mezipatro | K12.233718 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
233912 | 5.NP mezipatro | K12.233912 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
233947 | 5.NP mezipatro | K12.233947 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
233950 | 5.NP mezipatro | K12.233950 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
234019 | 5.NP mezipatro | K12.234019 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
234065 | 4.NP | K12.234065 | 4.NP | 78.54 | R-RS-VZT-ACC-05.1
234068 | 5.NP mezipatro | K12.234068 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
234085 | 1.S | K12.234085 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
234088 | 1.S | K12.234088 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
234091 | 1.S | K12.234091 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
234095 | 1.S | K12.234095 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
234097 | 1.S | K12.234097 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
234099 | 1.S | K12.234099 | 1.S | 78.54 | R-RS-VZT-ACC-05.1
234104 | 5.NP mezipatro | K12.234104 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
234108 | 5.NP mezipatro | K12.234108 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
234110 | 5.NP mezipatro | K12.234110 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1
234112 | 4.NP | K12.234112 | 4.NP | 78.54 | R-RS-VZT-ACC-05.1
234114 | 5.NP mezipatro | K12.234114 | 5.NP mezipatro | 78.54 | R-RS-VZT-ACC-05.1

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 4x10 + CYA25ZŽ (5)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 4x10 + CYA25ZŽ; ElementProjectSpecificDescription: CYKY-J 4x10 + CYA25ZŽ; ElementProjectSpecificIdentifier: K14; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 4x10 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:CYKY-J 4x10 + CYA25ZŽ:...) | Reference
115929 | K14.115929
115938 | K14.115938
115948 | K14.115948
115962 | K14.115962
115975 | K14.115975

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 4x35 + CYA25ZŽ (3)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 4x35 + CYA25ZŽ; ElementProjectSpecificDescription: CYKY-J 4x35 + CYA25ZŽ; ElementProjectSpecificIdentifier: K15; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 4x35 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:CYKY-J 4x35 + CYA25ZŽ:...) | Reference
116216 | K15.116216
116218 | K15.116218
116221 | K15.116221

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5 (16)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5; ElementProjectSpecificDescription: CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5; ElementProjectSpecificIdentifier: K16; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5:...) | In | Reference | StoreyProjectSpecificIdentifier | Length
115597 | 1.S | K16.115597 | 1.S | 157.08
115606 | 1.S | K16.115606 | 1.S | 157.08
115616 | 1.S | K16.115616 | 1.S | 157.08
115631 | 1.S | K16.115631 | 1.S | 157.08
115644 | 1.S | K16.115644 | 1.S | 157.08
117093 | 1.S | K16.117093 | 1.S | 78.54
117096 | 1.S | K16.117096 | 1.S | 78.54
117100 | 1.S | K16.117100 | 1.S | 78.54
117103 | 1.S | K16.117103 | 1.S | 78.54
117105 | 1.S | K16.117105 | 1.S | 78.54
117108 | 1.S | K16.117108 | 1.S | 78.54
117324 | 5.NP mezipatro | K16.117324 | 5.NP mezipatro | 78.54
117332 | 5.NP mezipatro | K16.117332 | 5.NP mezipatro | 78.54
117403 | 5.NP mezipatro | K16.117403 | 5.NP mezipatro | 78.54
117410 | 5.NP | K16.117410 | 5.NP | 78.54
117413 | 5.NP mezipatro | K16.117413 | 5.NP mezipatro | 78.54

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 5x16 + CYKY-O 3x1,5 (26)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 5x16 + CYKY-O 3x1,5; ElementProjectSpecificDescription: CYKY-J 5x16 + CYKY-O 3x1,5; ElementProjectSpecificIdentifier: K19; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 5x16 + CYKY-O 3x1,5
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_DistributionSystemCommon - Reference: RE-G
Name (#Elektroinstalační trubka, koleno:CYKY-J 5x16 + CYKY-O 3x1,5:...) | CZ_ElementCommon, Reference | Length | Pset_JunctionBoxTypeCommon, Reference
107276 | K19.107276 | 157.08 | RE-G1
107278 | K19.107278 | 157.08 | RE-G1
107384 | K19.107384 | 157.08 | RE-G1
107386 | K19.107386 | 78.54 | RE-G1
107389 | K19.107389 | 78.54 | RE-G1
107531 | K19.107531 | 157.08 | RE-G1
107562 | K19.107562 | 157.08 | RE-G2
107594 | K19.107594 | 157.08 | RE-G3
107596 | K19.107596 | 157.08 | RE-G3
107600 | K19.107600 | 157.08 | RE-G3
107602 | K19.107602 | 78.54 | RE-G3
107604 | K19.107604 | 78.54 | RE-G3
107607 | K19.107607 | 157.08 | RE-G3
107634 | K19.107634 | 157.08 | RE-G4
107636 | K19.107636 | 157.08 | RE-G4
107640 | K19.107640 | 157.08 | RE-G4
107642 | K19.107642 | 78.54 | RE-G4
107644 | K19.107644 | 78.54 | RE-G4
107647 | K19.107647 | 157.08 | RE-G4
139205 | K19.139205 | 157.08 | RE-G2
139246 | K19.139246 | 78.54 | RE-G2
139249 | K19.139249 | 78.54 | RE-G2
139345 | K19.139345 | 78.54 | RE-G2
139552 | K19.139552 | 78.54 | RE-G2
139556 | K19.139556 | 78.54 | RE-G2
139558 | K19.139558 | 78.54 | RE-G2

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 5x2,5 + CYA6ZŽ (52)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 5x2,5 + CYA6ZŽ; ElementProjectSpecificDescription: CYKY-J 5x2,5 + CYA6ZŽ; ElementProjectSpecificIdentifier: K17; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 5x2,5 + CYA6ZŽ
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Elektroinstalační trubka, koleno:CYKY-J 5x2,5 + CYA6ZŽ:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
94207 | 1.S mezipatro | K17.94207 | 1.S mezipatro | 78.54 | R-RS-VZT-01.1.01
94216 | 1.S mezipatro | K17.94216 | 1.S mezipatro | 78.54 | R-RS-VZT-01.1.01
94469 | 1.S mezipatro | K17.94469 | 1.S mezipatro | 39.27 | R-RS-VZT-01.1.01
94473 | 1.S mezipatro | K17.94473 | 1.S mezipatro | 78.54 | R-RS-VZT-01.1.01
94475 | 1.S mezipatro | K17.94475 | 1.S mezipatro | 39.27 | R-RS-VZT-01.1.01
94545 | 1.S | K17.94545 | 1.S | 78.54 | R-RS-VZT-01.1.01
94548 | 1.S | K17.94548 | 1.S | 78.54 | R-RS-VZT-01.1.01
94551 | 1.S | K17.94551 | 1.S | 78.54 | R-RS-VZT-01.1.01
94562 | 1.S | K17.94562 | 1.S | 78.54 | R-RS-VZT-01.1.01
94757 | 3.NP mezipatro | K17.94757 | 3.NP mezipatro | 78.54 | R-RS-VZT-01.1.01
94760 | 1.S | K17.94760 | 1.S | 78.54 | R-RS-VZT-01.1.01
94828 | 1.S mezipatro | K17.94828 | 1.S mezipatro | 78.54 | R-RS-VZT-01.1.01
94831 | 1.S mezipatro | K17.94831 | 1.S mezipatro | 78.54 | R-RS-VZT-01.1.01
95109 | 1.S mezipatro | K17.95109 | 1.S mezipatro | 78.54 | R-RS-VZT-1.1.01
95112 | 1.S mezipatro | K17.95112 | 1.S mezipatro | 78.54 | R-RS-VZT-1.1.01
95127 | 1.S | K17.95127 | 1.S | 78.54 | R-RS-VZT-1.1.01
95130 | 1.S | K17.95130 | 1.S | 78.54 | R-RS-VZT-1.1.01
95133 | 1.S | K17.95133 | 1.S | 78.54 | R-RS-VZT-1.1.01
95138 | 1.S | K17.95138 | 1.S | 78.54 | R-RS-VZT-1.1.01
95140 | 3.NP mezipatro | K17.95140 | 3.NP mezipatro | 78.54 | R-RS-VZT-1.1.01
95142 | 1.S | K17.95142 | 1.S | 78.54 | R-RS-VZT-1.1.01
95144 | 1.NP mezipatro | K17.95144 | 1.NP mezipatro | 78.54 | R-RS-VZT-1.1.01
95146 | 1.S mezipatro | K17.95146 | 1.S mezipatro | 78.54 | R-RS-VZT-1.1.01
95273 | 1.NP mezipatro | K17.95273 | 1.NP mezipatro | 39.27 | R-RS-VZT-1.1.01
95275 | 1.NP mezipatro | K17.95275 | 1.NP mezipatro | 78.54 | R-RS-VZT-1.1.01
95277 | 1.NP mezipatro | K17.95277 | 1.NP mezipatro | 39.27 | R-RS-VZT-1.1.01
95320 | 1.S mezipatro | K17.95320 | 1.S mezipatro | 78.54 | R-RS-VZT-2.1.01
95323 | 1.S mezipatro | K17.95323 | 1.S mezipatro | 78.54 | R-RS-VZT-2.1.01
95330 | 1.S | K17.95330 | 1.S | 78.54 | R-RS-VZT-2.1.01
95333 | 1.S | K17.95333 | 1.S | 78.54 | R-RS-VZT-2.1.01
95336 | 1.S | K17.95336 | 1.S | 78.54 | R-RS-VZT-2.1.01
95341 | 1.S | K17.95341 | 1.S | 78.54 | R-RS-VZT-2.1.01
95343 | 3.NP mezipatro | K17.95343 | 3.NP mezipatro | 78.54 | R-RS-VZT-2.1.01
95345 | 1.S | K17.95345 | 1.S | 78.54 | R-RS-VZT-2.1.01
95347 | 2.NP mezipatro | K17.95347 | 2.NP mezipatro | 78.54 | R-RS-VZT-2.1.01
95349 | 1.S mezipatro | K17.95349 | 1.S mezipatro | 78.54 | R-RS-VZT-2.1.01
95547 | 2.NP mezipatro | K17.95547 | 2.NP mezipatro | 39.27 | R-RS-VZT-2.1.01
95551 | 2.NP mezipatro | K17.95551 | 2.NP mezipatro | 78.54 | R-RS-VZT-2.1.01
95553 | 2.NP mezipatro | K17.95553 | 2.NP mezipatro | 39.27 | R-RS-VZT-2.1.01
95591 | 3.NP mezipatro | K17.95591 | 3.NP mezipatro | 78.54 | R-RS-VZT-3.1.01
95594 | 3.NP mezipatro | K17.95594 | 3.NP mezipatro | 78.54 | R-RS-VZT-3.1.01
95601 | 1.S | K17.95601 | 1.S | 78.54 | R-RS-VZT-3.1.01
95604 | 1.S | K17.95604 | 1.S | 78.54 | R-RS-VZT-3.1.01
95607 | 1.S | K17.95607 | 1.S | 78.54 | R-RS-VZT-3.1.01
95612 | 1.S | K17.95612 | 1.S | 78.54 | R-RS-VZT-3.1.01
95614 | 3.NP mezipatro | K17.95614 | 3.NP mezipatro | 78.54 | R-RS-VZT-3.1.01
95616 | 1.S | K17.95616 | 1.S | 78.54 | R-RS-VZT-3.1.01
95618 | 3.NP mezipatro | K17.95618 | 3.NP mezipatro | 78.54 | R-RS-VZT-3.1.01
95620 | 3.NP mezipatro | K17.95620 | 3.NP mezipatro | 78.54 | R-RS-VZT-3.1.01
95624 | 3.NP mezipatro | K17.95624 | 3.NP mezipatro | 39.27 | R-RS-VZT-3.1.01
95626 | 3.NP mezipatro | K17.95626 | 3.NP mezipatro | 78.54 | R-RS-VZT-3.1.01
95628 | 3.NP mezipatro | K17.95628 | 3.NP mezipatro | 39.27 | R-RS-VZT-3.1.01

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 5x4 + CYA 6zž (23)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 5x4 + CYA 6zž; ElementProjectSpecificDescription: CYKY-J 5x4 + CYA 6zž; ElementProjectSpecificIdentifier: K18; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 5x4 + CYA 6zž
Qto_CableSegmentBaseQuantities - Length: 78.54
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Elektroinstalační trubka, koleno:CYKY-J 5x4 + CYA 6zž:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Pset_JunctionBoxTypeCommon, Reference
98497 | 1.S | K18.98497 | 1.S | R-RS-VYT5.02
98500 | 1.S | K18.98500 | 1.S | R-RS-VYT5.02
98503 | 1.S | K18.98503 | 1.S | R-RS-VYT5.02
98508 | 1.S | K18.98508 | 1.S | R-RS-VYT5.02
98512 | 1.S | K18.98512 | 1.S | R-RS-VYT5.02
98662 | 5.NP | K18.98662 | 5.NP | R-RS-VYT5.02
98667 | 5.NP | K18.98667 | 5.NP | R-RS-VYT5.02
98671 | 5.NP | K18.98671 | 5.NP | R-RS-VYT5.02
98702 | 5.NP | K18.98702 | 5.NP | R-RS-VYT5.02
98714 | 5.NP | K18.98714 | 5.NP | R-RS-VYT5.02
98717 | 1.S | K18.98717 | 1.S | R-RS-VYT5.02
146483 | 1.S | K18.146483 | 1.S | R-RS-VYT5.01
146485 | 1.S | K18.146485 | 1.S | R-RS-VYT5.01
146488 | 1.S | K18.146488 | 1.S | R-RS-VYT5.01
146492 | 1.S | K18.146492 | 1.S | R-RS-VYT5.01
146498 | 1.S | K18.146498 | 1.S | R-RS-VYT5.01
146506 | 5.NP | K18.146506 | 5.NP | R-RS-VYT5.01
146516 | 5.NP | K18.146516 | 5.NP | R-RS-VYT5.01
146580 | 1.S | K18.146580 | 1.S | R-RS-VYT5.01
146582 | 5.NP mezipatro | K18.146582 | 5.NP mezipatro | R-RS-VYT5.01
235233 | 5.NP | K18.235233 | 5.NP | R-RS-VYT5.01
235235 | 5.NP | K18.235235 | 5.NP | R-RS-VYT5.01
235237 | 5.NP | K18.235237 | 5.NP | R-RS-VYT5.01

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-O 7x1,5 (3)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-O 7x1,5; ElementProjectSpecificDescription: CYKY-O 7x1,5; ElementProjectSpecificIdentifier: K20; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-O 7x1,5
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:CYKY-O 7x1,5:...) | Reference
116294 | K20.116294
116308 | K20.116308
116321 | K20.116321

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:H07RN-F 5Gx16 (4)
In: 5.NP mezipatro
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: H07RN-F 5Gx16; ElementProjectSpecificDescription: H07RN-F 5Gx16; ElementProjectSpecificIdentifier: K22; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: H07RN-F 5Gx16
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 5.NP mezipatro
Qto_CableSegmentBaseQuantities - Length: 78.54
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Name (#Elektroinstalační trubka, koleno:H07RN-F 5Gx16:...) | CZ_ElementCommon, Reference
231292 | K22.231292 | Pset_DistributionSystemCommon - Reference: RH
231295 | K22.231295 | Pset_DistributionSystemCommon - Reference: RH
231490 | K22.231490 | Pset_JunctionBoxTypeCommon - sets with these values: 3
231526 | K22.231526 | Pset_JunctionBoxTypeCommon - sets with these values: 3

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:Solar 6mm (93)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Solar 6mm; ElementProjectSpecificDescription: Solar 6mm; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: Solar 6mm
Pset_JunctionBoxTypeCommon - Reference: R-RDC-FVE
Pset_DistributionSystemCommon - Reference: RDC
Name (#Elektroinstalační trubka, koleno:Solar 6mm:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier | Length
104385 | 5.NP mezipatro | K21.104385 | String 1 | 5.NP mezipatro | 78.54
104390 | 5.NP mezipatro | K21.104390 | String 1 | 5.NP mezipatro | 78.54
104394 | 5.NP mezipatro | K21.104394 | String 1 | 5.NP mezipatro | 78.54
104399 | 5.NP mezipatro | K21.104399 | String 1 | 5.NP mezipatro | 78.54
104403 | 5.NP mezipatro | K21.104403 | String 1 | 5.NP mezipatro | 78.54
104515 | 5.NP mezipatro | K21.104515 | String 1 | 5.NP mezipatro | 78.54
104685 | Střecha | K21.104685 | String 1 | Střecha | 18.99
104768 | Střecha | K21.104768 | String 1 | Střecha | 78.54
104776 | Střecha | K21.104776 | String 1 | Střecha | 78.54
104786 | Střecha | K21.104786 | String 1 | Střecha | 78.54
104794 | Střecha | K21.104794 | String 1 | Střecha | 78.54
104804 | Střecha | K21.104804 | String 1 | Střecha | 78.54
104812 | Střecha | K21.104812 | String 1 | Střecha | 78.54
104822 | Střecha | K21.104822 | String 1 | Střecha | 78.54
104830 | Střecha | K21.104830 | String 1 | Střecha | 78.54
104840 | Střecha | K21.104840 | String 1 | Střecha | 78.54
104848 | Střecha | K21.104848 | String 1 | Střecha | 78.54
104858 | Střecha | K21.104858 | String 1 | Střecha | 78.54
104866 | Střecha | K21.104866 | String 1 | Střecha | 78.54
105337 | 5.NP mezipatro | K21.105337 | String 1 | 5.NP mezipatro | 78.54
105344 | 5.NP mezipatro | K21.105344 | String 1 | 5.NP mezipatro | 78.54
105347 | 5.NP mezipatro | K21.105347 | String 1 | 5.NP mezipatro | 78.54
105364 | 5.NP | K21.105364 | String 1 | 5.NP | 78.54
105367 | 5.NP mezipatro | K21.105367 | String 1 | 5.NP mezipatro | 78.54
105372 | 5.NP mezipatro | K21.105372 | String 1 | 5.NP mezipatro | 78.54
105538 | Střecha | K21.105538 | String 1 | Střecha | 24.047
105559 | Střecha | K21.105559 | String 1 | Střecha | 24.047
105567 | Střecha | K21.105567 | String 1 | Střecha | 78.54
105570 | Střecha | K21.105570 | String 1 | Střecha | 78.54
105587 | Střecha | K21.105587 | String 1 | Střecha | 78.54
105589 | Střecha | K21.105589 | String 1 | Střecha | 78.54
106207 | 5.NP mezipatro | K21.106207 | String 2 | 5.NP mezipatro | 78.54
106210 | 5.NP mezipatro | K21.106210 | String 2 | 5.NP mezipatro | 78.54
106213 | 5.NP mezipatro | K21.106213 | String 3 | 5.NP mezipatro | 78.54
106216 | 5.NP mezipatro | K21.106216 | String 3 | 5.NP mezipatro | 78.54
106261 | 5.NP mezipatro | K21.106261 | String 3 | 5.NP mezipatro | 78.54
106264 | 5.NP mezipatro | K21.106264 | String 3 | 5.NP mezipatro | 78.54
106269 | 5.NP mezipatro | K21.106269 | String 3 | 5.NP mezipatro | 78.54
106272 | 5.NP mezipatro | K21.106272 | String 3 | 5.NP mezipatro | 78.54
106277 | 5.NP mezipatro | K21.106277 | String 2 | 5.NP mezipatro | 78.54
106280 | 5.NP mezipatro | K21.106280 | String 2 | 5.NP mezipatro | 78.54
106285 | 5.NP mezipatro | K21.106285 | String 2 | 5.NP mezipatro | 78.54
106288 | 5.NP mezipatro | K21.106288 | String 2 | 5.NP mezipatro | 78.54
106314 | 5.NP mezipatro | K21.106314 | String 2 | 5.NP mezipatro | 78.54
106324 | 5.NP mezipatro | K21.106324 | String 2 | 5.NP mezipatro | 78.54
106334 | 5.NP mezipatro | K21.106334 | String 3 | 5.NP mezipatro | 78.54
106344 | 5.NP mezipatro | K21.106344 | String 3 | 5.NP mezipatro | 78.54
106357 | Střecha | K21.106357 | String 2 | Střecha | 78.54
106360 | 5.NP mezipatro | K21.106360 | String 2 | 5.NP mezipatro | 78.54
106368 | Střecha | K21.106368 | String 2 | Střecha | 78.54
106371 | 5.NP mezipatro | K21.106371 | String 2 | 5.NP mezipatro | 78.54
106379 | Střecha | K21.106379 | String 3 | Střecha | 78.54
106382 | 5.NP mezipatro | K21.106382 | String 3 | 5.NP mezipatro | 78.54
106394 | Střecha | K21.106394 | String 3 | Střecha | 78.54
106396 | 5.NP mezipatro | K21.106396 | String 3 | 5.NP mezipatro | 78.54
106460 | Střecha | K21.106460 | String 2 | Střecha | 24.047
106468 | Střecha | K21.106468 | String 2 | Střecha | 24.047
106473 | Střecha | K21.106473 | String 3 | Střecha | 24.047
106476 | Střecha | K21.106476 | String 3 | Střecha | 24.047
106481 | Střecha | K21.106481 | String 3 | Střecha | 24.047
106484 | Střecha | K21.106484 | String 3 | Střecha | 24.047
106489 | Střecha | K21.106489 | String 2 | Střecha | 78.54
106492 | Střecha | K21.106492 | String 2 | Střecha | 24.047
106499 | Střecha | K21.106499 | String 2 | Střecha | 78.54
106502 | Střecha | K21.106502 | String 2 | Střecha | 24.047
106509 | Střecha | K21.106509 | String 3 | Střecha | 78.54
106512 | Střecha | K21.106512 | String 3 | Střecha | 78.54
106567 | Střecha | K21.106567 | String 2 | Střecha | 78.54
106570 | Střecha | K21.106570 | String 2 | Střecha | 78.54
106633 | Střecha | K21.106633 | String 2 | Střecha | 78.54
106641 | Střecha | K21.106641 | String 2 | Střecha | 78.54
106651 | Střecha | K21.106651 | String 2 | Střecha | 78.54
106659 | Střecha | K21.106659 | String 2 | Střecha | 78.54
106669 | Střecha | K21.106669 | String 2 | Střecha | 78.54
106677 | Střecha | K21.106677 | String 2 | Střecha | 78.54
106687 | Střecha | K21.106687 | String 2 | Střecha | 78.54
106695 | Střecha | K21.106695 | String 2 | Střecha | 78.54
106707 | Střecha | K21.106707 | String 2 | Střecha | 78.54
106769 | Střecha | K21.106769 | String 2 | Střecha | 78.54
106796 | Střecha | K21.106796 | String 2 | Střecha | 78.54
106806 | Střecha | K21.106806 | String 2 | Střecha | 78.54
106824 | Střecha | K21.106824 | String 2 | Střecha | 78.54
106827 | Střecha | K21.106827 | String 2 | Střecha | 78.54
107755 | Střecha | K21.107755 | String 3 | Střecha | 78.54
107759 | Střecha | K21.107759 | String 3 | Střecha | 78.54
107763 | Střecha | K21.107763 | String 3 | Střecha | 78.54
107767 | Střecha | K21.107767 | String 3 | Střecha | 78.54
107771 | Střecha | K21.107771 | String 3 | Střecha | 78.54
107775 | Střecha | K21.107775 | String 3 | Střecha | 78.54
107779 | Střecha | K21.107779 | String 3 | Střecha | 78.54
107783 | Střecha | K21.107783 | String 3 | Střecha | 78.54
107789 | Střecha | K21.107789 | String 3 | Střecha | 78.54
107791 | Střecha | K21.107791 | String 3 | Střecha | 78.54

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:2xCXKH-V-J 5x10 (5)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: 2xCXKH-V-J 5x10; ElementProjectSpecificDescription: 2xCXKH-V-J 5x10; ElementProjectSpecificIdentifier: K01; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: 2xCXKH-V-J 5x10
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RPO
Name (Elektroinstalační trubka bez tvarovek:2xCXKH-V-J 5x10:...) | Reference | Length
116533 | K01.116533 | 1400
116536 | K01.116536 | 1090.72
116539 | K01.116539 | 1134.78
116542 | K01.116542 | 89.28
116545 | K01.116545 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:2xCYKY-J 3x120+70 + CYA25ZŽ (3)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: 2xCYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificDescription: 2xCYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificIdentifier: K02; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: 2xCYKY-J 3x120+70 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:2xCYKY-J 3x120+70 + CYA25ZŽ:...) | Reference | Length
115104 | K02.115104 | 1479.36
115105 | K02.115105 | 1400
115108 | K02.115108 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:2xCYY-J 4x150 (7)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: 2xCYY-J 4x150; ElementProjectSpecificDescription: 2xCYY-J 4x150; ElementProjectSpecificIdentifier: K03; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: 2xCYY-J 4x150
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: Trafo
Name (Elektroinstalační trubka bez tvarovek:2xCYY-J 4x150:...) | Reference | Length
113734 | K03.113734 | 960
113737 | K03.113737 | 1100
113740 | K03.113740 | 1800
113743 | K03.113743 | 1600
113746 | K03.113746 | 3506.12
113749 | K03.113749 | 2175.23
113925 | K03.113925 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CXKH-V-J 3x1,5 (724)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 3x1,5; ElementProjectSpecificDescription: CXKH-V-J 3x1,5; ElementProjectSpecificIdentifier: K04; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 3x1,5
Pset_DistributionSystemCommon - Reference: RPO
Name (Elektroinstalační trubka bez tvarovek:CXKH-V-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
54818 | 4.NP | K04.54818 | 4.NP | 142.85 | RPO-N4.11
54819 | 1.S | K04.54819 | 1.S | 269.004 | RPO-N4.11
54822 | 1.S | K04.54822 | 1.S | 2977.35 | RPO-N4.11
54823 | 1.S | K04.54823 | 1.S | 14528.9 | RPO-N4.11
54827 | 4.NP | K04.54827 | 4.NP | 11785 | RPO-N4.11
54837 | 1.S | K04.54837 | 1.S | 1065 | RPO-N4.11
55406 | 4.NP | K04.55406 | 4.NP | 3233.83 | RPO-N4.11
55417 | 4.NP | K04.55417 | 4.NP | 3010.97 | RPO-N4.11
55426 | 4.NP | K04.55426 | 4.NP | 58.17 | RPO-N4.11
55429 | 4.NP | K04.55429 | 4.NP | 2090.39 | RPO-N4.11
55434 | 4.NP | K04.55434 | 4.NP | 3007.36 | RPO-N4.11
55443 | 4.NP | K04.55443 | 4.NP | 120 | RPO-N4.11
55446 | 4.NP | K04.55446 | 4.NP | 5560.84 | RPO-N4.11
55451 | 4.NP | K04.55451 | 4.NP | 3010.97 | RPO-N4.11
55460 | 4.NP | K04.55460 | 4.NP | 120 | RPO-N4.11
55463 | 4.NP | K04.55463 | 4.NP | 5140.37 | RPO-N4.11
55468 | 4.NP | K04.55468 | 4.NP | 3010.97 | RPO-N4.11
55477 | 4.NP | K04.55477 | 4.NP | 120 | RPO-N4.11
55480 | 4.NP | K04.55480 | 4.NP | 5314.84 | RPO-N4.11
55485 | 4.NP | K04.55485 | 4.NP | 3006.06 | RPO-N4.11
55494 | 4.NP | K04.55494 | 4.NP | 120 | RPO-N4.11
55497 | 4.NP | K04.55497 | 4.NP | 4968.39 | RPO-N4.11
55502 | 4.NP | K04.55502 | 4.NP | 3010.97 | RPO-N4.11
55511 | 4.NP | K04.55511 | 4.NP | 120 | RPO-N4.11
55514 | 4.NP | K04.55514 | 4.NP | 5216.82 | RPO-N4.11
55519 | 4.NP | K04.55519 | 4.NP | 2571.55 | RPO-N4.11
55595 | 4.NP | K04.55595 | 4.NP | 2898.04 | RPO-N4.11
55604 | 4.NP | K04.55604 | 4.NP | 3055.16 | RPO-N4.11
55773 | 4.NP | K04.55773 | 4.NP | 139.39 | RPO-N4.11
55776 | 4.NP | K04.55776 | 4.NP | 2943.95 | RPO-N4.11
55955 | 4.NP | K04.55955 | 4.NP | 6595.87 | RPO-N4.11
57995 | 1.S | K04.57995 | 1.S | 254.004 | RPO-N4.01
57996 | 1.S | K04.57996 | 1.S | 3007.35 | RPO-N4.01
57997 | 1.S | K04.57997 | 1.S | 14543.9 | RPO-N4.01
57998 | 4.NP mezipatro | K04.57998 | 4.NP mezipatro | 13285 | RPO-N4.01
57999 | 1.S | K04.57999 | 1.S | 1065 | RPO-N4.01
58030 | 4.NP mezipatro | K04.58030 | 4.NP mezipatro | 6564.7 | RPO-N4.01
64676 | 4.NP | K04.64676 | 4.NP | 140.72 | RPO-N4.11
64677 | 4.NP | K04.64677 | 4.NP | 241.42 | RPO-N4.11
64770 | 4.NP | K04.64770 | 4.NP | 1714.6 | RPO-N4.11
66767 | 4.NP mezipatro | K04.66767 | 4.NP mezipatro | 2939.64 | RPO-N4.01
66844 | 4.NP mezipatro | K04.66844 | 4.NP mezipatro | 1507.12 | RPO-N4.01
66889 | 4.NP mezipatro | K04.66889 | 4.NP mezipatro | 1074.98 | RPO-N4.01
66910 | 4.NP mezipatro | K04.66910 | 4.NP mezipatro | 140.72 | RPO-N4.01
66911 | 4.NP mezipatro | K04.66911 | 4.NP mezipatro | 241.42 | RPO-N4.01
66937 | 4.NP mezipatro | K04.66937 | 4.NP mezipatro | 2249.32 | RPO-N4.01
66990 | 4.NP mezipatro | K04.66990 | 4.NP mezipatro | 120 | RPO-N4.01
66993 | 4.NP mezipatro | K04.66993 | 4.NP mezipatro | 4928.43 | RPO-N4.01
67018 | 4.NP mezipatro | K04.67018 | 4.NP mezipatro | 1507.12 | RPO-N4.01
67061 | 4.NP mezipatro | K04.67061 | 4.NP mezipatro | 120 | RPO-N4.01
67064 | 4.NP mezipatro | K04.67064 | 4.NP mezipatro | 5354.8 | RPO-N4.01
67090 | 4.NP mezipatro | K04.67090 | 4.NP mezipatro | 1507.12 | RPO-N4.01
67100 | 4.NP mezipatro | K04.67100 | 4.NP mezipatro | 1507.12 | RPO-N4.01
67112 | 4.NP mezipatro | K04.67112 | 4.NP mezipatro | 1507.12 | RPO-N4.01
67122 | 4.NP mezipatro | K04.67122 | 4.NP mezipatro | 1507.12 | RPO-N4.01
67138 | 4.NP mezipatro | K04.67138 | 4.NP mezipatro | 1457.12 | RPO-N4.01
67154 | 4.NP mezipatro | K04.67154 | 4.NP mezipatro | 2391.76 | RPO-N4.01
67170 | 4.NP mezipatro | K04.67170 | 4.NP mezipatro | 120 | RPO-N4.01
67173 | 4.NP mezipatro | K04.67173 | 4.NP mezipatro | 137.43 | RPO-N4.01
67185 | 4.NP mezipatro | K04.67185 | 4.NP mezipatro | 120 | RPO-N4.01
67188 | 4.NP mezipatro | K04.67188 | 4.NP mezipatro | 2823.8 | RPO-N4.01
67194 | 4.NP mezipatro | K04.67194 | 4.NP mezipatro | 120 | RPO-N4.01
67197 | 4.NP mezipatro | K04.67197 | 4.NP mezipatro | 4916.56 | RPO-N4.01
67203 | 4.NP mezipatro | K04.67203 | 4.NP mezipatro | 120 | RPO-N4.01
67206 | 4.NP mezipatro | K04.67206 | 4.NP mezipatro | 5359.61 | RPO-N4.01
67212 | 4.NP mezipatro | K04.67212 | 4.NP mezipatro | 120 | RPO-N4.01
67215 | 4.NP mezipatro | K04.67215 | 4.NP mezipatro | 5140.37 | RPO-N4.01
68979 | 1.S | K04.68979 | 1.S | 35920.9 | RPO-N0.01
68982 | 1.S | K04.68982 | 1.S | 4457.59 | RPO-N0.01
68987 | 1.S | K04.68987 | 1.S | 750.79 | RPO-N0.01
68991 | 1.S | K04.68991 | 1.S | 1099.96 | RPO-N0.01
68995 | 1.S | K04.68995 | 1.S | 5874.47 | RPO-N0.01
69000 | 1.S | K04.69000 | 1.S | 3049.05 | RPO-N0.01
69004 | 1.S | K04.69004 | 1.S | 302.41 | RPO-N0.01
69017 | 1.S | K04.69017 | 1.S | 1259.37 | RPO-N0.01
69018 | 1.S | K04.69018 | 1.S | 191.924 | RPO-N0.01
69030 | 1.S mezipatro | K04.69030 | 1.S mezipatro | 2362.61 | RPO-N0.01
69050 | 1.NP mezipatro | K04.69050 | 1.NP mezipatro | 1440 | RPO-N0.01
69118 | 1.S mezipatro | K04.69118 | 1.S mezipatro | 1677.51 | RPO-N0.01
69147 | 1.S mezipatro | K04.69147 | 1.S mezipatro | 1420 | RPO-N0.01
69163 | 1.NP | K04.69163 | 1.NP | 2163.57 | RPO-N0.01
69219 | 1.NP | K04.69219 | 1.NP | 2267.62 | RPO-N0.01
69258 | 1.NP | K04.69258 | 1.NP | 1440 | RPO-N0.01
69327 | 1.NP mezipatro | K04.69327 | 1.NP mezipatro | 2362.61 | RPO-N0.01
69328 | 1.NP mezipatro | K04.69328 | 1.NP mezipatro | 1677.51 | RPO-N0.01
69347 | 2.NP | K04.69347 | 2.NP | 2163.57 | RPO-N0.01
69348 | 2.NP | K04.69348 | 2.NP | 2267.62 | RPO-N0.01
69368 | 2.NP mezipatro | K04.69368 | 2.NP mezipatro | 2362.61 | RPO-N0.01
69369 | 2.NP mezipatro | K04.69369 | 2.NP mezipatro | 1677.51 | RPO-N0.01
69373 | 3.NP | K04.69373 | 3.NP | 2163.57 | RPO-N0.01
69374 | 3.NP | K04.69374 | 3.NP | 2267.62 | RPO-N0.01
69396 | 3.NP mezipatro | K04.69396 | 3.NP mezipatro | 2362.61 | RPO-N0.01
69397 | 3.NP mezipatro | K04.69397 | 3.NP mezipatro | 1677.51 | RPO-N0.01
69401 | 4.NP | K04.69401 | 4.NP | 2163.57 | RPO-N0.01
69402 | 4.NP | K04.69402 | 4.NP | 2267.62 | RPO-N0.01
69424 | 4.NP mezipatro | K04.69424 | 4.NP mezipatro | 2362.61 | RPO-N0.01
69425 | 4.NP mezipatro | K04.69425 | 4.NP mezipatro | 1677.51 | RPO-N0.01
69452 | 5.NP mezipatro | K04.69452 | 5.NP mezipatro | 2362.61 | RPO-N0.01
69457 | 5.NP mezipatro | K04.69457 | 5.NP mezipatro | 2163.57 | RPO-N0.01
69458 | 5.NP mezipatro | K04.69458 | 5.NP mezipatro | 2267.62 | RPO-N0.01
69505 | 5.NP mezipatro | K04.69505 | 5.NP mezipatro | 1677.51 | RPO-N0.01
69519 | 5.NP | K04.69519 | 5.NP | 3640 | RPO-N0.01
69527 | 4.NP mezipatro | K04.69527 | 4.NP mezipatro | 1440 | RPO-N0.01
69535 | 4.NP | K04.69535 | 4.NP | 1440 | RPO-N0.01
69543 | 3.NP mezipatro | K04.69543 | 3.NP mezipatro | 1440 | RPO-N0.01
69551 | 3.NP | K04.69551 | 3.NP | 1440 | RPO-N0.01
69559 | 2.NP mezipatro | K04.69559 | 2.NP mezipatro | 1440 | RPO-N0.01
69567 | 2.NP | K04.69567 | 2.NP | 1440 | RPO-N0.01
69786 | 1.S | K04.69786 | 1.S | 1285 | RPO-N0.01
72081 | 1.S mezipatro | K04.72081 | 1.S mezipatro | 2562.91 | RPO-N0.02
72082 | 1.S mezipatro | K04.72082 | 1.S mezipatro | 877.67 | RPO-N0.02
72085 | 1.NP | K04.72085 | 1.NP | 2562.91 | RPO-N0.02
72086 | 1.NP | K04.72086 | 1.NP | 2261.75 | RPO-N0.02
72089 | 1.NP mezipatro | K04.72089 | 1.NP mezipatro | 2562.91 | RPO-N0.02
72090 | 1.NP mezipatro | K04.72090 | 1.NP mezipatro | 891.6 | RPO-N0.02
72091 | 2.NP | K04.72091 | 2.NP | 2553.71 | RPO-N0.02
72092 | 2.NP | K04.72092 | 2.NP | 2266.05 | RPO-N0.02
72093 | 2.NP mezipatro | K04.72093 | 2.NP mezipatro | 2547.35 | RPO-N0.02
72094 | 2.NP mezipatro | K04.72094 | 2.NP mezipatro | 907.67 | RPO-N0.02
72095 | 3.NP | K04.72095 | 3.NP | 2554.24 | RPO-N0.02
72096 | 3.NP | K04.72096 | 3.NP | 2267.45 | RPO-N0.02
72097 | 3.NP mezipatro | K04.72097 | 3.NP mezipatro | 2554.24 | RPO-N0.02
72098 | 3.NP mezipatro | K04.72098 | 3.NP mezipatro | 917.67 | RPO-N0.02
72099 | 4.NP | K04.72099 | 4.NP | 2554.3 | RPO-N0.02
72100 | 4.NP | K04.72100 | 4.NP | 2267.45 | RPO-N0.02
72101 | 4.NP mezipatro | K04.72101 | 4.NP mezipatro | 2551.09 | RPO-N0.02
72102 | 4.NP mezipatro | K04.72102 | 4.NP mezipatro | 922.67 | RPO-N0.02
72103 | 5.NP mezipatro | K04.72103 | 5.NP mezipatro | 2345.21 | RPO-N0.02
72104 | 5.NP mezipatro | K04.72104 | 5.NP mezipatro | 2547.3 | RPO-N0.02
72145 | 1.S | K04.72145 | 1.S | 2627.91 | RPO-N0.02
72147 | 1.S | K04.72147 | 1.S | 2363.84 | RPO-N0.02
72152 | 1.S | K04.72152 | 1.S | 1273.19 | RPO-N0.02
72154 | 1.S mezipatro | K04.72154 | 1.S mezipatro | 1258.19 | RPO-N0.02
72158 | 5.NP | K04.72158 | 5.NP | 3620 | RPO-N0.02
72162 | 1.NP | K04.72162 | 1.NP | 1258.19 | RPO-N0.02
72164 | 1.NP mezipatro | K04.72164 | 1.NP mezipatro | 1258.19 | RPO-N0.02
72166 | 2.NP | K04.72166 | 2.NP | 1273.19 | RPO-N0.02
