Properties of the parts of a building model (IFC4), part 2 of 7

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x1,5 (1380)
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
71569 | 1.NP mezipatro | K09.71569 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71571 | 1.NP mezipatro | K09.71571 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71896 | 1.NP mezipatro | K09.71896 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71908 | 1.NP mezipatro | K09.71908 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71944 | 4.NP mezipatro | K09.71944 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71946 | 4.NP mezipatro | K09.71946 | 4.NP mezipatro | 39.27 | R-RS-LM4.04
71975 | 4.NP mezipatro | K09.71975 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71978 | 4.NP mezipatro | K09.71978 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71990 | 4.NP mezipatro | K09.71990 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71994 | 4.NP mezipatro | K09.71994 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71998 | 4.NP mezipatro | K09.71998 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
72005 | 4.NP mezipatro | K09.72005 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
72008 | 4.NP mezipatro | K09.72008 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
72020 | 4.NP mezipatro | K09.72020 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
72022 | 4.NP mezipatro | K09.72022 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
72028 | 4.NP mezipatro | K09.72028 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
72038 | 4.NP mezipatro | K09.72038 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
72040 | 4.NP mezipatro | K09.72040 | 4.NP mezipatro | 39.27 | R-RS-LM4.03
72042 | 4.NP mezipatro | K09.72042 | 4.NP mezipatro | 39.27 | R-RS-LM4.03
72044 | 4.NP mezipatro | K09.72044 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
72053 | 4.NP mezipatro | K09.72053 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
72055 | 4.NP mezipatro | K09.72055 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
74266 | 4.NP | K09.74266 | 4.NP | 78.54 | R-RS-LM4.13
74271 | 1.NP | K09.74271 | 1.NP | 78.54 | R-RS-LM1.13
74292 | 1.NP | K09.74292 | 1.NP | 78.54 | R-RS-LM1.13
74300 | 1.NP | K09.74300 | 1.NP | 78.54 | R-RS-LM1.13
74325 | 1.NP | K09.74325 | 1.NP | 78.54 | R-RS-LM1.13
74327 | 1.NP | K09.74327 | 1.NP | 78.54 | R-RS-LM1.13
74346 | 1.NP | K09.74346 | 1.NP | 78.54 | R-RS-LM1.13
74348 | 1.NP | K09.74348 | 1.NP | 78.54 | R-RS-LM1.13
74353 | 1.NP | K09.74353 | 1.NP | 39.27 | R-RS-LM1.13
74355 | 1.NP | K09.74355 | 1.NP | 39.27 | R-RS-LM1.13
74357 | 1.NP | K09.74357 | 1.NP | 78.54 | R-RS-LM1.13
74359 | 1.NP | K09.74359 | 1.NP | 78.54 | R-RS-LM1.13
74365 | 1.NP | K09.74365 | 1.NP | 78.54 | R-RS-LM1.13
74368 | 1.NP | K09.74368 | 1.NP | 78.54 | R-RS-LM1.13
74374 | 1.NP | K09.74374 | 1.NP | 78.54 | R-RS-LM1.13
74376 | 1.NP | K09.74376 | 1.NP | 78.54 | R-RS-LM1.13
74396 | 1.NP | K09.74396 | 1.NP | 78.54 | R-RS-LM1.13
74398 | 1.NP | K09.74398 | 1.NP | 39.27 | R-RS-LM1.13
74400 | 1.NP | K09.74400 | 1.NP | 39.27 | R-RS-LM1.13
74402 | 1.NP | K09.74402 | 1.NP | 78.54 | R-RS-LM1.13
74407 | 1.S | K09.74407 | 1.S | 78.54 | R-RS-LM1.13
74410 | 1.S | K09.74410 | 1.S | 78.54 | R-RS-LM1.13
74413 | 1.S | K09.74413 | 1.S | 78.54 | R-RS-LM1.13
74417 | 1.S | K09.74417 | 1.S | 78.54 | R-RS-LM1.13
74423 | 1.NP | K09.74423 | 1.NP | 78.54 | R-RS-LM1.13
74426 | 1.S | K09.74426 | 1.S | 78.54 | R-RS-LM1.13
74428 | 1.S | K09.74428 | 1.S | 78.54 | R-RS-LM1.13
74594 | 1.NP | K09.74594 | 1.NP | 78.54 | R-RS-LM1.13
74709 | 2.NP | K09.74709 | 2.NP | 78.54 | R-RS-LM2.13
74811 | 1.S | K09.74811 | 1.S | 78.54 | R-RS-LM2.13
74814 | 1.S | K09.74814 | 1.S | 78.54 | R-RS-LM2.13
74817 | 1.S | K09.74817 | 1.S | 78.54 | R-RS-LM2.13
74821 | 1.S | K09.74821 | 1.S | 78.54 | R-RS-LM2.13
74823 | 1.S | K09.74823 | 1.S | 78.54 | R-RS-LM2.13
74825 | 1.S | K09.74825 | 1.S | 78.54 | R-RS-LM2.13
75378 | 3.NP mezipatro | K09.75378 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75382 | 3.NP mezipatro | K09.75382 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75389 | 3.NP mezipatro | K09.75389 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75392 | 3.NP mezipatro | K09.75392 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75397 | 3.NP mezipatro | K09.75397 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75400 | 3.NP mezipatro | K09.75400 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75408 | 3.NP mezipatro | K09.75408 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75411 | 3.NP mezipatro | K09.75411 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75428 | 3.NP mezipatro | K09.75428 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75430 | 3.NP mezipatro | K09.75430 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75433 | 3.NP mezipatro | K09.75433 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75437 | 3.NP mezipatro | K09.75437 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75440 | 3.NP mezipatro | K09.75440 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75444 | 3.NP mezipatro | K09.75444 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75446 | 3.NP mezipatro | K09.75446 | 3.NP mezipatro | 39.27 | R-RS-LM3.03
75448 | 3.NP mezipatro | K09.75448 | 3.NP mezipatro | 39.27 | R-RS-LM3.03
75450 | 3.NP mezipatro | K09.75450 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75454 | 3.NP mezipatro | K09.75454 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75459 | 3.NP mezipatro | K09.75459 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75461 | 3.NP mezipatro | K09.75461 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75468 | 3.NP mezipatro | K09.75468 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75470 | 3.NP mezipatro | K09.75470 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75477 | 3.NP mezipatro | K09.75477 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75479 | 3.NP mezipatro | K09.75479 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75483 | 3.NP mezipatro | K09.75483 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75489 | 1.S | K09.75489 | 1.S | 78.54 | R-RS-LM3.03
75492 | 1.S | K09.75492 | 1.S | 78.54 | R-RS-LM3.03
75495 | 1.S | K09.75495 | 1.S | 78.54 | R-RS-LM3.03
75506 | 1.S | K09.75506 | 1.S | 78.54 | R-RS-LM3.03
75513 | 3.NP mezipatro | K09.75513 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75515 | 3.NP mezipatro | K09.75515 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75525 | 3.NP mezipatro | K09.75525 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75527 | 3.NP mezipatro | K09.75527 | 3.NP mezipatro | 39.27 | R-RS-LM3.03
75529 | 3.NP mezipatro | K09.75529 | 3.NP mezipatro | 39.27 | R-RS-LM3.03
75531 | 3.NP mezipatro | K09.75531 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75710 | 3.NP mezipatro | K09.75710 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75721 | 3.NP mezipatro | K09.75721 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
75744 | 3.NP mezipatro | K09.75744 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
76126 | 3.NP mezipatro | K09.76126 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
76491 | 1.S | K09.76491 | 1.S | 78.54 | R-RS-LM3.04
76494 | 1.S | K09.76494 | 1.S | 78.54 | R-RS-LM3.04
76497 | 1.S | K09.76497 | 1.S | 78.54 | R-RS-LM3.04
76500 | 1.S | K09.76500 | 1.S | 78.54 | R-RS-LM3.04
76503 | 1.S | K09.76503 | 1.S | 78.54 | R-RS-LM3.04
76514 | 3.NP mezipatro | K09.76514 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76521 | 3.NP mezipatro | K09.76521 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76529 | 3.NP mezipatro | K09.76529 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76547 | 3.NP mezipatro | K09.76547 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76550 | 3.NP mezipatro | K09.76550 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76553 | 3.NP mezipatro | K09.76553 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76559 | 3.NP mezipatro | K09.76559 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76562 | 3.NP mezipatro | K09.76562 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76565 | 3.NP mezipatro | K09.76565 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76568 | 3.NP mezipatro | K09.76568 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76576 | 3.NP mezipatro | K09.76576 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76578 | 3.NP mezipatro | K09.76578 | 3.NP mezipatro | 39.27 | R-RS-LM3.04
76580 | 3.NP mezipatro | K09.76580 | 3.NP mezipatro | 39.27 | R-RS-LM3.04
76582 | 3.NP mezipatro | K09.76582 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76588 | 3.NP mezipatro | K09.76588 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76590 | 3.NP mezipatro | K09.76590 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76597 | 3.NP mezipatro | K09.76597 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76599 | 3.NP mezipatro | K09.76599 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76603 | 3.NP mezipatro | K09.76603 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76605 | 3.NP mezipatro | K09.76605 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76615 | 3.NP mezipatro | K09.76615 | 3.NP mezipatro | 39.27 | R-RS-LM3.04
76617 | 3.NP mezipatro | K09.76617 | 3.NP mezipatro | 39.27 | R-RS-LM3.04
76625 | 3.NP mezipatro | K09.76625 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76628 | 3.NP mezipatro | K09.76628 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
76657 | 1.S | K09.76657 | 1.S | 78.54 | R-RS-LM3.04
78849 | 1.NP mezipatro | K09.78849 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78853 | 1.NP mezipatro | K09.78853 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78860 | 1.NP mezipatro | K09.78860 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78863 | 1.NP mezipatro | K09.78863 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78868 | 1.NP mezipatro | K09.78868 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78871 | 1.NP mezipatro | K09.78871 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78877 | 1.NP mezipatro | K09.78877 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78880 | 1.NP mezipatro | K09.78880 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78905 | 1.NP mezipatro | K09.78905 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78908 | 1.NP mezipatro | K09.78908 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78912 | 1.NP mezipatro | K09.78912 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78914 | 1.NP mezipatro | K09.78914 | 1.NP mezipatro | 39.27 | R-RS-LM1.06
78916 | 1.NP mezipatro | K09.78916 | 1.NP mezipatro | 39.27 | R-RS-LM1.06
78918 | 1.NP mezipatro | K09.78918 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78922 | 1.NP mezipatro | K09.78922 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78927 | 1.NP mezipatro | K09.78927 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78929 | 1.NP mezipatro | K09.78929 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78936 | 1.NP mezipatro | K09.78936 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78938 | 1.NP mezipatro | K09.78938 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78945 | 1.NP mezipatro | K09.78945 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78947 | 1.NP mezipatro | K09.78947 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78950 | 1.NP mezipatro | K09.78950 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78956 | 1.S | K09.78956 | 1.S | 78.54 | R-RS-LM1.06
78959 | 1.S | K09.78959 | 1.S | 78.54 | R-RS-LM1.06
78962 | 1.S | K09.78962 | 1.S | 78.54 | R-RS-LM1.06
78969 | 1.S | K09.78969 | 1.S | 78.54 | R-RS-LM1.06
78972 | 1.NP mezipatro | K09.78972 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78974 | 1.NP mezipatro | K09.78974 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78978 | 1.NP mezipatro | K09.78978 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78983 | 1.NP mezipatro | K09.78983 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78985 | 1.NP mezipatro | K09.78985 | 1.NP mezipatro | 39.27 | R-RS-LM1.06
78987 | 1.NP mezipatro | K09.78987 | 1.NP mezipatro | 39.27 | R-RS-LM1.06
78989 | 1.NP mezipatro | K09.78989 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78996 | 1.NP mezipatro | K09.78996 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
78998 | 1.NP mezipatro | K09.78998 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79020 | 1.NP mezipatro | K09.79020 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79187 | 1.NP mezipatro | K09.79187 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79192 | 1.NP mezipatro | K09.79192 | 1.NP mezipatro | 8.73 | R-RS-LM1.06
79211 | 1.NP mezipatro | K09.79211 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79215 | 1.NP mezipatro | K09.79215 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79220 | 1.NP mezipatro | K09.79220 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79392 | 1.NP mezipatro | K09.79392 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79394 | 1.NP mezipatro | K09.79394 | 1.NP mezipatro | 8.3 | R-RS-LM1.06
79489 | 1.NP mezipatro | K09.79489 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79552 | 1.NP mezipatro | K09.79552 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79584 | 1.NP mezipatro | K09.79584 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79626 | 1.NP mezipatro | K09.79626 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
79644 | 1.NP mezipatro | K09.79644 | 1.NP mezipatro | 78.54 | R-RS-LM1.06
84266 | 1.S | K09.84266 | 1.S | 78.54 | R-RS-LM0.02
84328 | 1.S | K09.84328 | 1.S | 78.54 | R-RS-LM0.02
84495 | 1.S | K09.84495 | 1.S | 78.54 | R-RS-LM0.03
84599 | 1.S | K09.84599 | 1.S | 78.54 | R-RS-LM0.03
84621 | 1.S | K09.84621 | 1.S | 78.54 | R-RS-LM0.03
84697 | 1.S | K09.84697 | 1.S | 78.54 | R-RS-LM0.03
84699 | 1.S | K09.84699 | 1.S | 39.27 | R-RS-LM0.03
84710 | 1.S | K09.84710 | 1.S | 78.54 | R-RS-LM1.01
84713 | 1.S | K09.84713 | 1.S | 78.54 | R-RS-LM1.01
84716 | 1.S | K09.84716 | 1.S | 78.54 | R-RS-LM1.01
84719 | 1.S | K09.84719 | 1.S | 78.54 | R-RS-LM1.01
84811 | 1.S | K09.84811 | 1.S | 78.54 | R-RS-LM1.01
84815 | 1.S | K09.84815 | 1.S | 78.54 | R-RS-LM1.01
84819 | 1.S | K09.84819 | 1.S | 78.54 | R-RS-LM1.01
85004 | 1.S | K09.85004 | 1.S | 78.54 | R-RS-LM1.01
85117 | 1.S | K09.85117 | 1.S | 78.54 | R-RS-LM0.01
85138 | 1.S | K09.85138 | 1.S | 78.54 | R-RS-LM0.01
85166 | 1.S | K09.85166 | 1.S | 78.54 | R-RS-LM0.01
85802 | 1.S | K09.85802 | 1.S | 78.54 | R-RS-LM0.04
85811 | 1.S | K09.85811 | 1.S | 78.54 | R-RS-LM0.04
85813 | 1.S | K09.85813 | 1.S | 78.54 | R-RS-LM0.04
85817 | 1.S | K09.85817 | 1.S | 78.54 | R-RS-LM0.04
85819 | 1.S | K09.85819 | 1.S | 39.27 | R-RS-LM0.04
85920 | 1.S | K09.85920 | 1.S | 78.54 | R-RS-LM0.05
86051 | 5.NP | K09.86051 | 5.NP | 78.54 | R-RS-LM1.01
86055 | 5.NP | K09.86055 | 5.NP | 78.54 | R-RS-LM1.01
86059 | 5.NP | K09.86059 | 5.NP | 78.54 | R-RS-LM1.01
86063 | 5.NP | K09.86063 | 5.NP | 78.54 | R-RS-LM1.01
86067 | 5.NP | K09.86067 | 5.NP | 78.54 | R-RS-LM1.01
86071 | 5.NP | K09.86071 | 5.NP | 78.54 | R-RS-LM1.01
86074 | 5.NP | K09.86074 | 5.NP | 78.54 | R-RS-LM1.01
86077 | 5.NP | K09.86077 | 5.NP | 78.54 | R-RS-LM1.01
86080 | 5.NP | K09.86080 | 5.NP | 78.54 | R-RS-LM1.01
86083 | 5.NP | K09.86083 | 5.NP | 78.54 | R-RS-LM1.01
86092 | 5.NP | K09.86092 | 5.NP | 78.54 | R-RS-LM1.01
86094 | 5.NP | K09.86094 | 5.NP | 78.54 | R-RS-LM1.01
86106 | 4.NP mezipatro | K09.86106 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
86109 | 4.NP mezipatro | K09.86109 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
86112 | 4.NP mezipatro | K09.86112 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
86115 | 4.NP mezipatro | K09.86115 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
86118 | 4.NP mezipatro | K09.86118 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
86120 | 4.NP mezipatro | K09.86120 | 4.NP mezipatro | 78.54 | R-RS-LM1.01
86132 | 1.S mezipatro | K09.86132 | 1.S mezipatro | 78.54 | R-RS-LM1.01
86135 | 1.S mezipatro | K09.86135 | 1.S mezipatro | 78.54 | R-RS-LM1.01
86138 | 1.S mezipatro | K09.86138 | 1.S mezipatro | 78.54 | R-RS-LM1.01
86141 | 1.S mezipatro | K09.86141 | 1.S mezipatro | 78.54 | R-RS-LM1.01
86144 | 1.S mezipatro | K09.86144 | 1.S mezipatro | 78.54 | R-RS-LM1.01
86146 | 1.S mezipatro | K09.86146 | 1.S mezipatro | 78.54 | R-RS-LM1.01
86158 | 2.NP mezipatro | K09.86158 | 2.NP mezipatro | 78.54 | R-RS-LM1.01
86161 | 2.NP mezipatro | K09.86161 | 2.NP mezipatro | 78.54 | R-RS-LM1.01
86164 | 2.NP mezipatro | K09.86164 | 2.NP mezipatro | 78.54 | R-RS-LM1.01
86167 | 2.NP mezipatro | K09.86167 | 2.NP mezipatro | 78.54 | R-RS-LM1.01
86170 | 2.NP mezipatro | K09.86170 | 2.NP mezipatro | 78.54 | R-RS-LM1.01
86184 | 3.NP mezipatro | K09.86184 | 3.NP mezipatro | 78.54 | R-RS-LM1.01
86187 | 3.NP mezipatro | K09.86187 | 3.NP mezipatro | 78.54 | R-RS-LM1.01
86190 | 3.NP mezipatro | K09.86190 | 3.NP mezipatro | 78.54 | R-RS-LM1.01
86193 | 3.NP mezipatro | K09.86193 | 3.NP mezipatro | 78.54 | R-RS-LM1.01
86196 | 3.NP mezipatro | K09.86196 | 3.NP mezipatro | 78.54 | R-RS-LM1.01
86198 | 3.NP mezipatro | K09.86198 | 3.NP mezipatro | 78.54 | R-RS-LM1.01
86210 | 1.NP mezipatro | K09.86210 | 1.NP mezipatro | 78.54 | R-RS-LM1.01
86213 | 1.NP mezipatro | K09.86213 | 1.NP mezipatro | 78.54 | R-RS-LM1.01
86216 | 1.NP mezipatro | K09.86216 | 1.NP mezipatro | 78.54 | R-RS-LM1.01
86219 | 1.NP mezipatro | K09.86219 | 1.NP mezipatro | 78.54 | R-RS-LM1.01
86222 | 1.NP mezipatro | K09.86222 | 1.NP mezipatro | 78.54 | R-RS-LM1.01
86235 | 4.NP | K09.86235 | 4.NP | 78.54 | R-RS-LM1.01
86238 | 4.NP | K09.86238 | 4.NP | 78.54 | R-RS-LM1.01
86241 | 4.NP | K09.86241 | 4.NP | 78.54 | R-RS-LM1.01
86244 | 4.NP | K09.86244 | 4.NP | 78.54 | R-RS-LM1.01
86247 | 4.NP | K09.86247 | 4.NP | 78.54 | R-RS-LM1.01
86249 | 4.NP | K09.86249 | 4.NP | 78.54 | R-RS-LM1.01
86261 | 1.S | K09.86261 | 1.S | 78.54 | R-RS-LM1.01
86264 | 1.S | K09.86264 | 1.S | 78.54 | R-RS-LM1.01
86267 | 1.S | K09.86267 | 1.S | 78.54 | R-RS-LM1.01
86270 | 1.S | K09.86270 | 1.S | 78.54 | R-RS-LM1.01
86273 | 1.S | K09.86273 | 1.S | 78.54 | R-RS-LM1.01
86275 | 1.S | K09.86275 | 1.S | 78.54 | R-RS-LM1.01
86287 | 1.NP | K09.86287 | 1.NP | 78.54 | R-RS-LM1.01
86290 | 1.NP | K09.86290 | 1.NP | 78.54 | R-RS-LM1.01
86293 | 1.NP | K09.86293 | 1.NP | 78.54 | R-RS-LM1.01
86296 | 1.NP | K09.86296 | 1.NP | 78.54 | R-RS-LM1.01
86299 | 1.NP | K09.86299 | 1.NP | 78.54 | R-RS-LM1.01
86301 | 1.NP | K09.86301 | 1.NP | 78.54 | R-RS-LM1.01
86313 | 2.NP | K09.86313 | 2.NP | 78.54 | R-RS-LM1.01
86316 | 2.NP | K09.86316 | 2.NP | 78.54 | R-RS-LM1.01
86319 | 2.NP | K09.86319 | 2.NP | 78.54 | R-RS-LM1.01
86322 | 2.NP | K09.86322 | 2.NP | 78.54 | R-RS-LM1.01
86325 | 2.NP | K09.86325 | 2.NP | 78.54 | R-RS-LM1.01
86327 | 2.NP | K09.86327 | 2.NP | 78.54 | R-RS-LM1.01
86339 | 3.NP | K09.86339 | 3.NP | 78.54 | R-RS-LM1.01
86342 | 3.NP | K09.86342 | 3.NP | 78.54 | R-RS-LM1.01
86345 | 3.NP | K09.86345 | 3.NP | 78.54 | R-RS-LM1.01
86348 | 3.NP | K09.86348 | 3.NP | 78.54 | R-RS-LM1.01
86351 | 3.NP | K09.86351 | 3.NP | 78.54 | R-RS-LM1.01
86491 | 1.S | K09.86491 | 1.S | 78.54 | R-RS-LM1.02
86494 | 1.S | K09.86494 | 1.S | 78.54 | R-RS-LM1.02
86503 | 1.S | K09.86503 | 1.S | 78.54 | R-RS-LM1.02
86761 | 1.S | K09.86761 | 1.S | 78.54 | R-RS-LM1.02
86823 | 5.NP | K09.86823 | 5.NP | 78.54 | R-RS-LM1.02
86909 | 1.S | K09.86909 | 1.S | 78.54 | R-RS-LM1.02
86912 | 1.S | K09.86912 | 1.S | 78.54 | R-RS-LM1.02
87074 | 4.NP | K09.87074 | 4.NP | 78.54 | R-RS-LM1.02
87084 | 4.NP | K09.87084 | 4.NP | 78.54 | R-RS-LM1.02
87092 | 4.NP | K09.87092 | 4.NP | 78.54 | R-RS-LM1.02
87102 | 4.NP | K09.87102 | 4.NP | 78.54 | R-RS-LM1.02
87110 | 4.NP | K09.87110 | 4.NP | 78.54 | R-RS-LM1.02
87120 | 4.NP | K09.87120 | 4.NP | 78.54 | R-RS-LM1.02
87224 | 4.NP | K09.87224 | 4.NP | 78.54 | R-RS-LM1.02
87242 | 4.NP | K09.87242 | 4.NP | 78.54 | R-RS-LM1.02
87253 | 4.NP | K09.87253 | 4.NP | 78.54 | R-RS-LM1.02
87261 | 4.NP | K09.87261 | 4.NP | 78.54 | R-RS-LM1.02
87390 | 4.NP | K09.87390 | 4.NP | 78.54 | R-RS-LM1.02
87398 | 4.NP | K09.87398 | 4.NP | 78.54 | R-RS-LM1.02
87408 | 4.NP | K09.87408 | 4.NP | 78.54 | R-RS-LM1.02
87513 | 4.NP | K09.87513 | 4.NP | 78.54 | R-RS-LM1.02
87516 | 4.NP | K09.87516 | 4.NP | 78.54 | R-RS-LM1.02
87519 | 4.NP | K09.87519 | 4.NP | 78.54 | R-RS-LM1.02
87523 | 4.NP | K09.87523 | 4.NP | 78.54 | R-RS-LM1.02
87526 | 4.NP | K09.87526 | 4.NP | 78.54 | R-RS-LM1.02
87529 | 4.NP | K09.87529 | 4.NP | 78.54 | R-RS-LM1.02
87571 | 4.NP | K09.87571 | 4.NP | 78.54 | R-RS-LM1.02
87593 | 4.NP mezipatro | K09.87593 | 4.NP mezipatro | 78.54 | R-RS-LM1.02
87596 | 4.NP mezipatro | K09.87596 | 4.NP mezipatro | 78.54 | R-RS-LM1.02
87599 | 4.NP mezipatro | K09.87599 | 4.NP mezipatro | 78.54 | R-RS-LM1.02
87602 | 4.NP mezipatro | K09.87602 | 4.NP mezipatro | 78.54 | R-RS-LM1.02
87605 | 4.NP mezipatro | K09.87605 | 4.NP mezipatro | 78.54 | R-RS-LM1.02
87608 | 4.NP mezipatro | K09.87608 | 4.NP mezipatro | 78.54 | R-RS-LM1.02
87654 | 4.NP | K09.87654 | 4.NP | 78.54 | R-RS-LM1.02
87846 | 3.NP mezipatro | K09.87846 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
87849 | 3.NP mezipatro | K09.87849 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
87852 | 3.NP mezipatro | K09.87852 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
87855 | 3.NP mezipatro | K09.87855 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
87858 | 3.NP mezipatro | K09.87858 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
87861 | 3.NP mezipatro | K09.87861 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
87999 | 1.S mezipatro | K09.87999 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88002 | 1.S mezipatro | K09.88002 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88005 | 1.S mezipatro | K09.88005 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88008 | 1.S mezipatro | K09.88008 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88011 | 1.S mezipatro | K09.88011 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88014 | 1.S mezipatro | K09.88014 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88035 | 1.NP mezipatro | K09.88035 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88038 | 1.NP mezipatro | K09.88038 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88041 | 1.NP mezipatro | K09.88041 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88044 | 1.NP mezipatro | K09.88044 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88047 | 1.NP mezipatro | K09.88047 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88050 | 1.NP mezipatro | K09.88050 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88053 | 1.NP mezipatro | K09.88053 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88071 | 2.NP mezipatro | K09.88071 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88074 | 2.NP mezipatro | K09.88074 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88077 | 2.NP mezipatro | K09.88077 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88080 | 2.NP mezipatro | K09.88080 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88083 | 2.NP mezipatro | K09.88083 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88086 | 2.NP mezipatro | K09.88086 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88089 | 2.NP mezipatro | K09.88089 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88315 | 1.S mezipatro | K09.88315 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88318 | 1.S mezipatro | K09.88318 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88321 | 1.S mezipatro | K09.88321 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88324 | 1.S mezipatro | K09.88324 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88327 | 1.S mezipatro | K09.88327 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88330 | 1.S mezipatro | K09.88330 | 1.S mezipatro | 78.54 | R-RS-LM1.02
88334 | 1.S | K09.88334 | 1.S | 78.54 | R-RS-LM1.02
88352 | 1.NP mezipatro | K09.88352 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88355 | 1.NP mezipatro | K09.88355 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88358 | 1.NP mezipatro | K09.88358 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88361 | 1.NP mezipatro | K09.88361 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88364 | 1.NP mezipatro | K09.88364 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88367 | 1.NP mezipatro | K09.88367 | 1.NP mezipatro | 78.54 | R-RS-LM1.02
88371 | 1.NP | K09.88371 | 1.NP | 78.54 | R-RS-LM1.02
88389 | 2.NP mezipatro | K09.88389 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88392 | 2.NP mezipatro | K09.88392 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88395 | 2.NP mezipatro | K09.88395 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88398 | 2.NP mezipatro | K09.88398 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88401 | 2.NP mezipatro | K09.88401 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88404 | 2.NP mezipatro | K09.88404 | 2.NP mezipatro | 78.54 | R-RS-LM1.02
88408 | 2.NP | K09.88408 | 2.NP | 78.54 | R-RS-LM1.02
88426 | 3.NP mezipatro | K09.88426 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
88429 | 3.NP mezipatro | K09.88429 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
88432 | 3.NP mezipatro | K09.88432 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
88435 | 3.NP mezipatro | K09.88435 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
88438 | 3.NP mezipatro | K09.88438 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
88441 | 3.NP mezipatro | K09.88441 | 3.NP mezipatro | 78.54 | R-RS-LM1.02
88445 | 3.NP | K09.88445 | 3.NP | 78.54 | R-RS-LM1.02
88470 | 1.S | K09.88470 | 1.S | 78.54 | R-RS-LM1.02
88485 | 1.NP | K09.88485 | 1.NP | 78.54 | R-RS-LM1.02
88499 | 2.NP | K09.88499 | 2.NP | 78.54 | R-RS-LM1.02
88513 | 3.NP | K09.88513 | 3.NP | 78.54 | R-RS-LM1.02
88527 | 4.NP | K09.88527 | 4.NP | 78.54 | R-RS-LM1.02
89295 | 4.NP | K09.89295 | 4.NP | 78.54 | R-RS-LM4.14
89335 | 4.NP | K09.89335 | 4.NP | 78.54 | R-RS-LM4.14
89337 | 4.NP | K09.89337 | 4.NP | 78.54 | R-RS-LM4.14
89347 | 4.NP | K09.89347 | 4.NP | 78.54 | R-RS-LM4.14
89350 | 4.NP | K09.89350 | 4.NP | 78.54 | R-RS-LM4.14
89521 | 1.S | K09.89521 | 1.S | 78.54 | R-RS-LM4.14
89524 | 1.S | K09.89524 | 1.S | 78.54 | R-RS-LM4.14
89840 | 1.S | K09.89840 | 1.S | 78.54 | R-RS-LM1.14
89843 | 1.S | K09.89843 | 1.S | 78.54 | R-RS-LM1.14
89846 | 1.S | K09.89846 | 1.S | 78.54 | R-RS-LM1.14
89851 | 1.S | K09.89851 | 1.S | 78.54 | R-RS-LM1.14
89857 | 1.NP | K09.89857 | 1.NP | 78.54 | R-RS-LM1.14
89870 | 1.NP | K09.89870 | 1.NP | 78.54 | R-RS-LM1.14
89880 | 1.NP | K09.89880 | 1.NP | 78.54 | R-RS-LM1.14
89885 | 1.NP | K09.89885 | 1.NP | 78.54 | R-RS-LM1.14
89887 | 1.NP | K09.89887 | 1.NP | 39.27 | R-RS-LM1.14
89889 | 1.NP | K09.89889 | 1.NP | 39.27 | R-RS-LM1.14
89904 | 1.NP | K09.89904 | 1.NP | 78.54 | R-RS-LM1.14
89907 | 1.NP | K09.89907 | 1.NP | 78.54 | R-RS-LM1.14
89913 | 1.NP | K09.89913 | 1.NP | 78.54 | R-RS-LM1.14
89916 | 1.NP | K09.89916 | 1.NP | 78.54 | R-RS-LM1.14
89919 | 1.NP | K09.89919 | 1.NP | 78.54 | R-RS-LM1.14
89928 | 1.NP | K09.89928 | 1.NP | 78.54 | R-RS-LM1.14
89931 | 1.NP | K09.89931 | 1.NP | 78.54 | R-RS-LM1.14
89934 | 1.NP | K09.89934 | 1.NP | 78.54 | R-RS-LM1.14
89939 | 1.NP | K09.89939 | 1.NP | 78.54 | R-RS-LM1.14
89942 | 1.NP | K09.89942 | 1.NP | 78.54 | R-RS-LM1.14
89945 | 1.NP | K09.89945 | 1.NP | 78.54 | R-RS-LM1.14
89953 | 1.NP | K09.89953 | 1.NP | 78.54 | R-RS-LM1.14
89956 | 1.NP | K09.89956 | 1.NP | 78.54 | R-RS-LM1.14
89959 | 1.NP | K09.89959 | 1.NP | 78.54 | R-RS-LM1.14
89962 | 1.NP | K09.89962 | 1.NP | 78.54 | R-RS-LM1.14
89965 | 1.NP | K09.89965 | 1.NP | 78.54 | R-RS-LM1.14
89973 | 1.NP | K09.89973 | 1.NP | 8.25 | R-RS-LM1.14
89975 | 1.NP | K09.89975 | 1.NP | 78.54 | R-RS-LM1.14
89983 | 1.NP | K09.89983 | 1.NP | 78.54 | R-RS-LM1.14
89987 | 1.NP | K09.89987 | 1.NP | 78.54 | R-RS-LM1.14
89990 | 1.NP | K09.89990 | 1.NP | 78.54 | R-RS-LM1.14
89993 | 1.NP | K09.89993 | 1.NP | 78.54 | R-RS-LM1.14
89995 | 1.NP | K09.89995 | 1.NP | 78.54 | R-RS-LM1.14
89998 | 1.NP | K09.89998 | 1.NP | 78.54 | R-RS-LM1.14
90002 | 1.NP | K09.90002 | 1.NP | 78.54 | R-RS-LM1.14
90004 | 1.NP | K09.90004 | 1.NP | 39.27 | R-RS-LM1.14
90006 | 1.NP | K09.90006 | 1.NP | 39.27 | R-RS-LM1.14
90008 | 1.NP | K09.90008 | 1.NP | 78.54 | R-RS-LM1.14
90017 | 1.NP | K09.90017 | 1.NP | 78.54 | R-RS-LM1.14
90019 | 1.NP | K09.90019 | 1.NP | 78.54 | R-RS-LM1.14
90021 | 1.NP | K09.90021 | 1.NP | 78.54 | R-RS-LM1.14
90023 | 1.NP | K09.90023 | 1.NP | 78.54 | R-RS-LM1.14
90025 | 1.S | K09.90025 | 1.S | 78.54 | R-RS-LM1.14
90027 | 1.S | K09.90027 | 1.S | 78.54 | R-RS-LM1.14
90433 | 1.NP | K09.90433 | 1.NP | 78.54 | R-RS-LM1.14
90435 | 1.NP | K09.90435 | 1.NP | 39.27 | R-RS-LM1.14
90454 | 1.NP | K09.90454 | 1.NP | 78.54 | R-RS-LM1.14
90472 | 1.NP | K09.90472 | 1.NP | 78.54 | R-RS-LM1.14
90553 | 1.NP | K09.90553 | 1.NP | 39.27 | R-RS-LM1.14
90652 | 1.S | K09.90652 | 1.S | 78.54 | R-RS-LM2.14
90655 | 1.S | K09.90655 | 1.S | 78.54 | R-RS-LM2.14
90658 | 1.S | K09.90658 | 1.S | 78.54 | R-RS-LM2.14
90663 | 1.S | K09.90663 | 1.S | 78.54 | R-RS-LM2.14
90669 | 2.NP | K09.90669 | 2.NP | 78.54 | R-RS-LM2.14
90682 | 2.NP | K09.90682 | 2.NP | 78.54 | R-RS-LM2.14
90707 | 2.NP | K09.90707 | 2.NP | 78.54 | R-RS-LM2.14
90710 | 2.NP | K09.90710 | 2.NP | 78.54 | R-RS-LM2.14
90713 | 2.NP | K09.90713 | 2.NP | 78.54 | R-RS-LM2.14
90716 | 2.NP | K09.90716 | 2.NP | 78.54 | R-RS-LM2.14
90719 | 2.NP | K09.90719 | 2.NP | 78.54 | R-RS-LM2.14
90722 | 2.NP | K09.90722 | 2.NP | 78.54 | R-RS-LM2.14
90729 | 2.NP | K09.90729 | 2.NP | 78.54 | R-RS-LM2.14
90732 | 2.NP | K09.90732 | 2.NP | 78.54 | R-RS-LM2.14
90735 | 2.NP | K09.90735 | 2.NP | 78.54 | R-RS-LM2.14
90739 | 2.NP | K09.90739 | 2.NP | 78.54 | R-RS-LM2.14
90742 | 2.NP | K09.90742 | 2.NP | 78.54 | R-RS-LM2.14
90745 | 2.NP | K09.90745 | 2.NP | 78.54 | R-RS-LM2.14
90753 | 2.NP | K09.90753 | 2.NP | 78.54 | R-RS-LM2.14
90756 | 2.NP | K09.90756 | 2.NP | 78.54 | R-RS-LM2.14
90759 | 2.NP | K09.90759 | 2.NP | 78.54 | R-RS-LM2.14
90762 | 2.NP | K09.90762 | 2.NP | 78.54 | R-RS-LM2.14
90765 | 2.NP | K09.90765 | 2.NP | 78.54 | R-RS-LM2.14
90773 | 2.NP | K09.90773 | 2.NP | 8.25 | R-RS-LM2.14
90775 | 2.NP | K09.90775 | 2.NP | 78.54 | R-RS-LM2.14
90783 | 2.NP | K09.90783 | 2.NP | 78.54 | R-RS-LM2.14
90787 | 2.NP | K09.90787 | 2.NP | 78.54 | R-RS-LM2.14
90790 | 2.NP | K09.90790 | 2.NP | 78.54 | R-RS-LM2.14
90793 | 2.NP | K09.90793 | 2.NP | 78.54 | R-RS-LM2.14
90795 | 2.NP | K09.90795 | 2.NP | 78.54 | R-RS-LM2.14
90802 | 2.NP | K09.90802 | 2.NP | 78.54 | R-RS-LM2.14
90804 | 2.NP | K09.90804 | 2.NP | 39.27 | R-RS-LM2.14
90806 | 2.NP | K09.90806 | 2.NP | 39.27 | R-RS-LM2.14
90808 | 2.NP | K09.90808 | 2.NP | 78.54 | R-RS-LM2.14
90817 | 2.NP | K09.90817 | 2.NP | 78.54 | R-RS-LM2.14
90819 | 2.NP | K09.90819 | 2.NP | 78.54 | R-RS-LM2.14
90821 | 2.NP | K09.90821 | 2.NP | 78.54 | R-RS-LM2.14
90823 | 2.NP | K09.90823 | 2.NP | 78.54 | R-RS-LM2.14
90825 | 1.S | K09.90825 | 1.S | 78.54 | R-RS-LM2.14
90827 | 1.S | K09.90827 | 1.S | 78.54 | R-RS-LM2.14
91190 | 2.NP | K09.91190 | 2.NP | 78.54 | R-RS-LM2.14
91201 | 2.NP | K09.91201 | 2.NP | 78.54 | R-RS-LM2.14
91216 | 2.NP | K09.91216 | 2.NP | 78.54 | R-RS-LM2.14
91218 | 2.NP | K09.91218 | 2.NP | 39.27 | R-RS-LM2.14
91265 | 2.NP | K09.91265 | 2.NP | 39.27 | R-RS-LM2.14
91329 | 2.NP | K09.91329 | 2.NP | 78.54 | R-RS-LM2.14
91354 | 2.NP | K09.91354 | 2.NP | 78.54 | R-RS-LM2.14
91357 | 2.NP | K09.91357 | 2.NP | 78.54 | R-RS-LM2.14
91448 | 2.NP | K09.91448 | 2.NP | 39.27 | R-RS-LM2.14
91450 | 2.NP | K09.91450 | 2.NP | 39.27 | R-RS-LM2.14
92068 | 1.S | K09.92068 | 1.S | 78.54 | R-RS-LM3.14
92071 | 1.S | K09.92071 | 1.S | 78.54 | R-RS-LM3.14
92074 | 1.S | K09.92074 | 1.S | 78.54 | R-RS-LM3.14
92079 | 1.S | K09.92079 | 1.S | 78.54 | R-RS-LM3.14
92084 | 3.NP | K09.92084 | 3.NP | 78.54 | R-RS-LM3.14
92112 | 3.NP | K09.92112 | 3.NP | 78.54 | R-RS-LM3.14
92115 | 3.NP | K09.92115 | 3.NP | 78.54 | R-RS-LM3.14
92137 | 3.NP | K09.92137 | 3.NP | 78.54 | R-RS-LM3.14
92140 | 3.NP | K09.92140 | 3.NP | 78.54 | R-RS-LM3.14
92143 | 3.NP | K09.92143 | 3.NP | 78.54 | R-RS-LM3.14
92151 | 3.NP | K09.92151 | 3.NP | 78.54 | R-RS-LM3.14
92154 | 3.NP | K09.92154 | 3.NP | 78.54 | R-RS-LM3.14
92157 | 3.NP | K09.92157 | 3.NP | 78.54 | R-RS-LM3.14
92160 | 3.NP | K09.92160 | 3.NP | 78.54 | R-RS-LM3.14
92163 | 3.NP | K09.92163 | 3.NP | 78.54 | R-RS-LM3.14
92171 | 3.NP | K09.92171 | 3.NP | 8.25 | R-RS-LM3.14
92173 | 3.NP | K09.92173 | 3.NP | 78.54 | R-RS-LM3.14
92181 | 3.NP | K09.92181 | 3.NP | 78.54 | R-RS-LM3.14
92185 | 3.NP | K09.92185 | 3.NP | 78.54 | R-RS-LM3.14
92188 | 3.NP | K09.92188 | 3.NP | 78.54 | R-RS-LM3.14
92191 | 3.NP | K09.92191 | 3.NP | 78.54 | R-RS-LM3.14
92193 | 3.NP | K09.92193 | 3.NP | 78.54 | R-RS-LM3.14
92198 | 3.NP | K09.92198 | 3.NP | 78.54 | R-RS-LM3.14
92200 | 3.NP | K09.92200 | 3.NP | 39.27 | R-RS-LM3.14
92202 | 3.NP | K09.92202 | 3.NP | 39.27 | R-RS-LM3.14
92217 | 3.NP | K09.92217 | 3.NP | 78.54 | R-RS-LM3.14
92221 | 1.S | K09.92221 | 1.S | 78.54 | R-RS-LM3.14
92223 | 1.S | K09.92223 | 1.S | 78.54 | R-RS-LM3.14
92246 | 3.NP | K09.92246 | 3.NP | 78.54 | R-RS-LM3.14
92252 | 3.NP | K09.92252 | 3.NP | 78.54 | R-RS-LM3.14
92255 | 3.NP | K09.92255 | 3.NP | 78.54 | R-RS-LM3.14
92516 | 1.S | K09.92516 | 1.S | 78.54 | R-RS-LM0.07
92525 | 1.S | K09.92525 | 1.S | 78.54 | R-RS-LM0.07
92527 | 1.S | K09.92527 | 1.S | 78.54 | R-RS-LM0.07
92531 | 1.S | K09.92531 | 1.S | 78.54 | R-RS-LM0.07
92533 | 1.S | K09.92533 | 1.S | 39.27 | R-RS-LM0.07
92535 | 1.S | K09.92535 | 1.S | 39.27 | R-RS-LM0.07
92585 | 1.S | K09.92585 | 1.S | 78.54 | R-RS-LM0.07
92589 | 1.S | K09.92589 | 1.S | 78.54 | R-RS-LM0.07
92593 | 1.S | K09.92593 | 1.S | 78.54 | R-RS-LM0.07
92601 | 1.S | K09.92601 | 1.S | 33.16 | R-RS-LM0.07
92603 | 1.S | K09.92603 | 1.S | 33.16 | R-RS-LM0.07
92610 | 1.S | K09.92610 | 1.S | 78.54 | R-RS-LM0.08/A
92619 | 1.S | K09.92619 | 1.S | 78.54 | R-RS-LM0.08/A
92681 | 1.S | K09.92681 | 1.S | 78.54 | R-RS-LM0.08/B
92690 | 1.S | K09.92690 | 1.S | 78.54 | R-RS-LM0.08/B
92692 | 1.S | K09.92692 | 1.S | 78.54 | R-RS-LM0.08/B
92745 | 1.S mezipatro | K09.92745 | 1.S mezipatro | 78.54 | R-RS-LM0.08/B
92750 | 1.S mezipatro | K09.92750 | 1.S mezipatro | 78.54 | R-RS-LM0.08/B
92754 | 1.S mezipatro | K09.92754 | 1.S mezipatro | 78.54 | R-RS-LM0.08/B
92765 | 1.S | K09.92765 | 1.S | 78.54 | R-RS-LM0.08/C
92774 | 1.S | K09.92774 | 1.S | 78.54 | R-RS-LM0.08/C
92832 | 1.S mezipatro | K09.92832 | 1.S mezipatro | 78.54 | R-RS-LM0.08/C
92834 | 1.S | K09.92834 | 1.S | 78.54 | R-RS-LM0.08/C
92841 | 1.S | K09.92841 | 1.S | 78.54 | R-RS-LM0.09
92850 | 1.S | K09.92850 | 1.S | 78.54 | R-RS-LM0.09
92852 | 1.S | K09.92852 | 1.S | 78.54 | R-RS-LM0.09
93096 | 1.S | K09.93096 | 1.S | 78.54 | R-RS-LM5.14
93099 | 1.S | K09.93099 | 1.S | 78.54 | R-RS-LM5.14
93103 | 1.S | K09.93103 | 1.S | 78.54 | R-RS-LM5.14
93106 | 1.S | K09.93106 | 1.S | 78.54 | R-RS-LM5.14
93108 | 1.S | K09.93108 | 1.S | 78.54 | R-RS-LM5.14
93110 | 1.S | K09.93110 | 1.S | 78.54 | R-RS-LM5.14
93202 | 5.NP | K09.93202 | 5.NP | 78.54 | R-RS-LM5.14
93229 | 5.NP | K09.93229 | 5.NP | 78.54 | R-RS-LM5.14
93231 | 5.NP | K09.93231 | 5.NP | 78.54 | R-RS-LM5.14
93236 | 5.NP | K09.93236 | 5.NP | 78.54 | R-RS-LM5.14
93241 | 5.NP | K09.93241 | 5.NP | 78.54 | R-RS-LM5.14
93245 | 5.NP | K09.93245 | 5.NP | 78.54 | R-RS-LM5.14
93249 | 5.NP | K09.93249 | 5.NP | 78.54 | R-RS-LM5.14
93253 | 5.NP | K09.93253 | 5.NP | 78.54 | R-RS-LM5.14
93257 | 5.NP | K09.93257 | 5.NP | 78.54 | R-RS-LM5.14
93268 | 5.NP | K09.93268 | 5.NP | 78.54 | R-RS-LM5.14
93273 | 5.NP | K09.93273 | 5.NP | 78.54 | R-RS-LM5.14
93277 | 5.NP | K09.93277 | 5.NP | 78.54 | R-RS-LM5.14
93281 | 5.NP | K09.93281 | 5.NP | 78.54 | R-RS-LM5.14
93285 | 5.NP | K09.93285 | 5.NP | 78.54 | R-RS-LM5.14
93289 | 5.NP | K09.93289 | 5.NP | 78.54 | R-RS-LM5.14
93299 | 1.S | K09.93299 | 1.S | 78.54 | R-RS-LM5.15
93302 | 1.S | K09.93302 | 1.S | 78.54 | R-RS-LM5.15
93306 | 1.S | K09.93306 | 1.S | 78.54 | R-RS-LM5.15
93309 | 1.S | K09.93309 | 1.S | 78.54 | R-RS-LM5.15
93311 | 1.S | K09.93311 | 1.S | 78.54 | R-RS-LM5.15
93313 | 1.S | K09.93313 | 1.S | 78.54 | R-RS-LM5.15
93316 | 5.NP | K09.93316 | 5.NP | 78.54 | R-RS-LM5.15
93533 | 5.NP | K09.93533 | 5.NP | 78.54 | R-RS-LM5.15
93559 | 5.NP | K09.93559 | 5.NP | 78.54 | R-RS-LM5.15
93567 | 5.NP | K09.93567 | 5.NP | 78.54 | R-RS-LM5.15
93577 | 5.NP | K09.93577 | 5.NP | 78.54 | R-RS-LM5.15
93733 | 5.NP | K09.93733 | 5.NP | 78.54 | R-RS-LM5.15
93735 | 5.NP | K09.93735 | 5.NP | 78.54 | R-RS-LM5.15
93771 | 5.NP | K09.93771 | 5.NP | 78.54 | R-RS-LM5.15
93781 | 5.NP | K09.93781 | 5.NP | 78.54 | R-RS-LM5.15
93873 | 5.NP | K09.93873 | 5.NP | 15.55 | R-RS-LM5.15
93884 | 5.NP | K09.93884 | 5.NP | 15.55 | R-RS-LM5.15
94852 | 1.S | K09.94852 | 1.S | 78.54 | R-RS-LM5.04
94855 | 1.S | K09.94855 | 1.S | 78.54 | R-RS-LM5.04
94859 | 1.S | K09.94859 | 1.S | 78.54 | R-RS-LM5.04
94864 | 1.S | K09.94864 | 1.S | 78.54 | R-RS-LM5.04
94866 | 1.S | K09.94866 | 1.S | 78.54 | R-RS-LM5.04
94984 | 5.NP | K09.94984 | 5.NP | 78.54 | R-RS-LM5.04
94997 | 1.S | K09.94997 | 1.S | 78.54 | R-RS-LM5.04
95006 | 5.NP | K09.95006 | 5.NP | 78.54 | R-RS-LM5.04
95035 | 5.NP | K09.95035 | 5.NP | 78.54 | R-RS-LM5.04
95044 | 5.NP | K09.95044 | 5.NP | 78.54 | R-RS-LM5.04
95049 | 5.NP | K09.95049 | 5.NP | 78.54 | R-RS-LM5.04
95053 | 5.NP | K09.95053 | 5.NP | 78.54 | R-RS-LM5.04
95057 | 5.NP | K09.95057 | 5.NP | 78.54 | R-RS-LM5.04
95061 | 5.NP | K09.95061 | 5.NP | 78.54 | R-RS-LM5.04
95065 | 5.NP | K09.95065 | 5.NP | 78.54 | R-RS-LM5.04
95069 | 5.NP | K09.95069 | 5.NP | 78.54 | R-RS-LM5.04
95073 | 5.NP | K09.95073 | 5.NP | 78.54 | R-RS-LM5.04
95077 | 5.NP | K09.95077 | 5.NP | 78.54 | R-RS-LM5.04
95081 | 5.NP | K09.95081 | 5.NP | 78.54 | R-RS-LM5.04
95085 | 5.NP | K09.95085 | 5.NP | 78.54 | R-RS-LM5.04
95089 | 5.NP | K09.95089 | 5.NP | 78.54 | R-RS-LM5.04
95093 | 5.NP | K09.95093 | 5.NP | 78.54 | R-RS-LM5.04
95801 | 1.S | K09.95801 | 1.S | 78.54 | R-RS-LM5.13
95804 | 1.S | K09.95804 | 1.S | 78.54 | R-RS-LM5.13
95808 | 1.S | K09.95808 | 1.S | 78.54 | R-RS-LM5.13
95811 | 1.S | K09.95811 | 1.S | 78.54 | R-RS-LM5.13
95813 | 1.S | K09.95813 | 1.S | 78.54 | R-RS-LM5.13
95826 | 1.S | K09.95826 | 1.S | 78.54 | R-RS-LM5.13
96041 | 5.NP | K09.96041 | 5.NP | 78.54 | R-RS-LM5.13
96063 | 5.NP | K09.96063 | 5.NP | 78.54 | R-RS-LM5.13
96067 | 5.NP | K09.96067 | 5.NP | 78.54 | R-RS-LM5.13
96071 | 5.NP | K09.96071 | 5.NP | 78.54 | R-RS-LM5.13
96078 | 5.NP | K09.96078 | 5.NP | 78.54 | R-RS-LM5.13
96081 | 5.NP | K09.96081 | 5.NP | 78.54 | R-RS-LM5.13
96092 | 5.NP | K09.96092 | 5.NP | 78.54 | R-RS-LM5.13
96096 | 5.NP | K09.96096 | 5.NP | 78.54 | R-RS-LM5.13
96100 | 5.NP | K09.96100 | 5.NP | 78.54 | R-RS-LM5.13
96104 | 5.NP | K09.96104 | 5.NP | 78.54 | R-RS-LM5.13
96116 | 5.NP | K09.96116 | 5.NP | 78.54 | R-RS-LM5.13
96120 | 5.NP | K09.96120 | 5.NP | 78.54 | R-RS-LM5.13
96124 | 5.NP | K09.96124 | 5.NP | 78.54 | R-RS-LM5.13
96128 | 5.NP | K09.96128 | 5.NP | 78.54 | R-RS-LM5.13
96144 | 5.NP | K09.96144 | 5.NP | 78.54 | R-RS-LM5.13
96148 | 5.NP | K09.96148 | 5.NP | 78.54 | R-RS-LM5.13
96152 | 5.NP | K09.96152 | 5.NP | 78.54 | R-RS-LM5.13
96156 | 5.NP | K09.96156 | 5.NP | 78.54 | R-RS-LM5.13
96164 | 5.NP | K09.96164 | 5.NP | 78.54 | R-RS-LM5.13
96166 | 5.NP | K09.96166 | 5.NP | 78.54 | R-RS-LM5.13
96174 | 5.NP | K09.96174 | 5.NP | 78.54 | R-RS-LM5.13
96176 | 5.NP | K09.96176 | 5.NP | 78.54 | R-RS-LM5.13
96188 | 5.NP | K09.96188 | 5.NP | 78.54 | R-RS-LM5.13
96192 | 5.NP | K09.96192 | 5.NP | 78.54 | R-RS-LM5.13
96194 | 5.NP | K09.96194 | 5.NP | 78.54 | R-RS-LM5.13
96196 | 5.NP | K09.96196 | 5.NP | 78.54 | R-RS-LM5.13
96255 | 1.S | K09.96255 | 1.S | 78.54 | R-RS-LM5.03
96258 | 1.S | K09.96258 | 1.S | 78.54 | R-RS-LM5.03
96262 | 1.S | K09.96262 | 1.S | 78.54 | R-RS-LM5.03
96265 | 1.S | K09.96265 | 1.S | 78.54 | R-RS-LM5.03
96267 | 1.S | K09.96267 | 1.S | 78.54 | R-RS-LM5.03
96271 | 1.S | K09.96271 | 1.S | 78.54 | R-RS-LM5.03
96276 | 5.NP | K09.96276 | 5.NP | 78.54 | R-RS-LM5.03
96484 | 5.NP | K09.96484 | 5.NP | 78.54 | R-RS-LM5.03
96523 | 5.NP | K09.96523 | 5.NP | 78.54 | R-RS-LM5.03
96534 | 5.NP | K09.96534 | 5.NP | 78.54 | R-RS-LM5.03
96542 | 5.NP | K09.96542 | 5.NP | 78.54 | R-RS-LM5.03
96633 | 1.S | K09.96633 | 1.S | 78.54 | R-RS-LM0.01
96635 | 1.S | K09.96635 | 1.S | 39.27 | R-RS-LM0.01
96637 | 1.S | K09.96637 | 1.S | 39.27 | R-RS-LM0.01
96639 | 1.S | K09.96639 | 1.S | 78.54 | R-RS-LM0.01
96646 | 1.S | K09.96646 | 1.S | 78.54 | R-RS-LM0.01
96667 | 1.S | K09.96667 | 1.S | 39.27 | R-RS-LM0.01
96669 | 1.S | K09.96669 | 1.S | 39.27 | R-RS-LM0.01
96671 | 1.S | K09.96671 | 1.S | 78.54 | R-RS-LM0.01
96673 | 1.S | K09.96673 | 1.S | 78.54 | R-RS-LM0.01
96681 | 1.S | K09.96681 | 1.S | 78.54 | R-RS-LM0.01
96686 | 1.S | K09.96686 | 1.S | 78.54 | R-RS-LM0.01
96688 | 1.S | K09.96688 | 1.S | 78.54 | R-RS-LM0.01
96710 | 1.S | K09.96710 | 1.S | 78.54 | R-RS-LM0.01
96712 | 1.S | K09.96712 | 1.S | 39.27 | R-RS-LM0.01
96714 | 1.S | K09.96714 | 1.S | 78.54 | R-RS-LM0.01
96716 | 1.S | K09.96716 | 1.S | 39.27 | R-RS-LM0.01
96951 | 1.S | K09.96951 | 1.S | 78.54 | R-RS-VZT.01
96955 | 1.S | K09.96955 | 1.S | 78.54 | R-RS-VZT.01
97148 | 1.S | K09.97148 | 1.S | 78.54 | R-RS-VZT.01
97173 | 1.S | K09.97173 | 1.S | 78.54 | R-RS-VZT.01
97202 | 1.S | K09.97202 | 1.S | 78.54 | R-RS-VZT.01
97238 | 1.S | K09.97238 | 1.S | 78.54 | R-RS-VZT.01
98391 | 1.S | K09.98391 | 1.S | 78.54 | R-RS-LM0.02
98393 | 1.S | K09.98393 | 1.S | 39.27 | R-RS-LM0.02
98410 | 1.S | K09.98410 | 1.S | 78.54 | R-RS-LM0.02
98416 | 1.S | K09.98416 | 1.S | 78.54 | R-RS-LM0.03
98418 | 1.S | K09.98418 | 1.S | 78.54 | R-RS-LM0.03
98429 | 1.S | K09.98429 | 1.S | 78.54 | R-RS-LM0.03
98431 | 1.S | K09.98431 | 1.S | 39.27 | R-RS-LM0.03
98440 | 1.S | K09.98440 | 1.S | 78.54 | R-RS-LM0.04
98442 | 1.S | K09.98442 | 1.S | 39.27 | R-RS-LM0.04
98451 | 1.S | K09.98451 | 1.S | 78.54 | R-RS-LM0.04
98454 | 1.S | K09.98454 | 1.S | 78.54 | R-RS-LM0.04
99316 | 1.S | K09.99316 | 1.S | 78.54 | R-RS-LM0.05
99321 | 1.S | K09.99321 | 1.S | 78.54 | R-RS-LM0.05
99323 | 1.S | K09.99323 | 1.S | 78.54 | R-RS-LM0.05
99368 | 1.S | K09.99368 | 1.S | 78.54 | R-RS-LM0.06
99370 | 1.S | K09.99370 | 1.S | 78.54 | R-RS-LM0.06
99695 | 1.S | K09.99695 | 1.S | 78.54 | R-RS-LM0.08/A
99699 | 1.S | K09.99699 | 1.S | 78.54 | R-RS-LM0.08/A
99701 | 1.S | K09.99701 | 1.S | 78.54 | R-RS-LM0.08/A
99983 | 1.S | K09.99983 | 1.S | 78.54 | R-RS-LM0.09
100110 | 1.S | K09.100110 | 1.S | 78.54 | R-RS-LM0.08/B
100112 | 1.S | K09.100112 | 1.S | 39.27 | R-RS-LM0.08/B
100114 | 1.S | K09.100114 | 1.S | 39.27 | R-RS-LM0.08/B
100116 | 1.S mezipatro | K09.100116 | 1.S mezipatro | 78.54 | R-RS-LM0.08/B
100272 | 1.S | K09.100272 | 1.S | 78.54 | R-RS-LM0.05
100367 | 1.S | K09.100367 | 1.S | 78.54 | R-RS-LM0.06
100369 | 1.S | K09.100369 | 1.S | 39.27 | R-RS-LM0.06
100371 | 1.S | K09.100371 | 1.S | 39.27 | R-RS-LM0.06
100576 | 1.S | K09.100576 | 1.S | 78.54 | R-RS-LM0.05
100579 | 1.S | K09.100579 | 1.S | 39.27 | R-RS-LM0.05
100581 | 1.S | K09.100581 | 1.S | 39.27 | R-RS-LM0.05
100843 | 2.NP mezipatro | K09.100843 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100847 | 2.NP mezipatro | K09.100847 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100854 | 2.NP mezipatro | K09.100854 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100857 | 2.NP mezipatro | K09.100857 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100862 | 2.NP mezipatro | K09.100862 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100865 | 2.NP mezipatro | K09.100865 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100871 | 2.NP mezipatro | K09.100871 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100874 | 2.NP mezipatro | K09.100874 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100899 | 2.NP mezipatro | K09.100899 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100902 | 2.NP mezipatro | K09.100902 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100906 | 2.NP mezipatro | K09.100906 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100908 | 2.NP mezipatro | K09.100908 | 2.NP mezipatro | 39.27 | R-RS-LM2.03
100910 | 2.NP mezipatro | K09.100910 | 2.NP mezipatro | 39.27 | R-RS-LM2.03
100912 | 2.NP mezipatro | K09.100912 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100916 | 2.NP mezipatro | K09.100916 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100921 | 2.NP mezipatro | K09.100921 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100923 | 2.NP mezipatro | K09.100923 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100930 | 2.NP mezipatro | K09.100930 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100932 | 2.NP mezipatro | K09.100932 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100939 | 2.NP mezipatro | K09.100939 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100941 | 2.NP mezipatro | K09.100941 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100944 | 2.NP mezipatro | K09.100944 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100950 | 1.S | K09.100950 | 1.S | 78.54 | R-RS-LM2.03
100953 | 1.S | K09.100953 | 1.S | 78.54 | R-RS-LM2.03
100956 | 1.S | K09.100956 | 1.S | 78.54 | R-RS-LM2.03
100963 | 1.S | K09.100963 | 1.S | 78.54 | R-RS-LM2.03
100966 | 2.NP mezipatro | K09.100966 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100968 | 2.NP mezipatro | K09.100968 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100972 | 2.NP mezipatro | K09.100972 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100977 | 2.NP mezipatro | K09.100977 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100979 | 2.NP mezipatro | K09.100979 | 2.NP mezipatro | 39.27 | R-RS-LM2.03
100981 | 2.NP mezipatro | K09.100981 | 2.NP mezipatro | 39.27 | R-RS-LM2.03
100983 | 2.NP mezipatro | K09.100983 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100990 | 2.NP mezipatro | K09.100990 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
100992 | 2.NP mezipatro | K09.100992 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101014 | 2.NP mezipatro | K09.101014 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101027 | 2.NP mezipatro | K09.101027 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101030 | 2.NP mezipatro | K09.101030 | 2.NP mezipatro | 8.73 | R-RS-LM2.03
101033 | 2.NP mezipatro | K09.101033 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101036 | 2.NP mezipatro | K09.101036 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101040 | 2.NP mezipatro | K09.101040 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101049 | 2.NP mezipatro | K09.101049 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101051 | 2.NP mezipatro | K09.101051 | 2.NP mezipatro | 8.3 | R-RS-LM2.03
101054 | 2.NP mezipatro | K09.101054 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101057 | 2.NP mezipatro | K09.101057 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101060 | 2.NP mezipatro | K09.101060 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101063 | 2.NP mezipatro | K09.101063 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101066 | 2.NP mezipatro | K09.101066 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101740 | 2.NP mezipatro | K09.101740 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101742 | 2.NP mezipatro | K09.101742 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
101774 | 3.NP mezipatro | K09.101774 | 3.NP mezipatro | 8.73 | R-RS-LM3.03
101780 | 3.NP mezipatro | K09.101780 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101784 | 3.NP mezipatro | K09.101784 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101792 | 3.NP mezipatro | K09.101792 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101795 | 3.NP mezipatro | K09.101795 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101798 | 3.NP mezipatro | K09.101798 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101801 | 3.NP mezipatro | K09.101801 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101804 | 3.NP mezipatro | K09.101804 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101886 | 3.NP mezipatro | K09.101886 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101888 | 3.NP mezipatro | K09.101888 | 3.NP mezipatro | 8.3 | R-RS-LM3.03
101898 | 3.NP mezipatro | K09.101898 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
101900 | 3.NP mezipatro | K09.101900 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
102570 | 3.NP | K09.102570 | 3.NP | 78.54 | R-RS-LM3.13
102597 | 3.NP | K09.102597 | 3.NP | 78.54 | R-RS-LM3.13
102614 | 3.NP | K09.102614 | 3.NP | 78.54 | R-RS-LM3.13
102616 | 3.NP | K09.102616 | 3.NP | 78.54 | R-RS-LM3.13
102634 | 3.NP | K09.102634 | 3.NP | 78.54 | R-RS-LM3.13
102636 | 3.NP | K09.102636 | 3.NP | 78.54 | R-RS-LM3.13
102641 | 3.NP | K09.102641 | 3.NP | 39.27 | R-RS-LM3.13
102643 | 3.NP | K09.102643 | 3.NP | 39.27 | R-RS-LM3.13
102645 | 3.NP | K09.102645 | 3.NP | 78.54 | R-RS-LM3.13
102647 | 3.NP | K09.102647 | 3.NP | 78.54 | R-RS-LM3.13
102653 | 3.NP | K09.102653 | 3.NP | 78.54 | R-RS-LM3.13
102656 | 3.NP | K09.102656 | 3.NP | 78.54 | R-RS-LM3.13
102662 | 3.NP | K09.102662 | 3.NP | 78.54 | R-RS-LM3.13
102664 | 3.NP | K09.102664 | 3.NP | 78.54 | R-RS-LM3.13
102675 | 3.NP | K09.102675 | 3.NP | 78.54 | R-RS-LM3.13
102677 | 3.NP | K09.102677 | 3.NP | 39.27 | R-RS-LM3.13
102679 | 3.NP | K09.102679 | 3.NP | 39.27 | R-RS-LM3.13
102681 | 3.NP | K09.102681 | 3.NP | 78.54 | R-RS-LM3.13
102684 | 3.NP | K09.102684 | 3.NP | 78.54 | R-RS-LM3.13
102690 | 3.NP | K09.102690 | 3.NP | 78.54 | R-RS-LM3.13
102692 | 3.NP | K09.102692 | 3.NP | 78.54 | R-RS-LM3.13
102699 | 3.NP | K09.102699 | 3.NP | 78.54 | R-RS-LM3.13
102701 | 3.NP | K09.102701 | 3.NP | 78.54 | R-RS-LM3.13
102705 | 3.NP | K09.102705 | 3.NP | 78.54 | R-RS-LM3.13
102712 | 1.S | K09.102712 | 1.S | 78.54 | R-RS-LM3.13
102715 | 1.S | K09.102715 | 1.S | 78.54 | R-RS-LM3.13
102718 | 1.S | K09.102718 | 1.S | 78.54 | R-RS-LM3.13
102722 | 1.S | K09.102722 | 1.S | 78.54 | R-RS-LM3.13
102724 | 1.S | K09.102724 | 1.S | 78.54 | R-RS-LM3.13
102726 | 1.S | K09.102726 | 1.S | 78.54 | R-RS-LM3.13
103454 | 1.S mezipatro | K09.103454 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103465 | 1.S mezipatro | K09.103465 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103468 | 1.S mezipatro | K09.103468 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103473 | 1.S mezipatro | K09.103473 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103476 | 1.S mezipatro | K09.103476 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103482 | 1.S mezipatro | K09.103482 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103485 | 1.S mezipatro | K09.103485 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103501 | 1.S mezipatro | K09.103501 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103503 | 1.S mezipatro | K09.103503 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103506 | 1.S mezipatro | K09.103506 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103510 | 1.S mezipatro | K09.103510 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103513 | 1.S mezipatro | K09.103513 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103517 | 1.S mezipatro | K09.103517 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103519 | 1.S mezipatro | K09.103519 | 1.S mezipatro | 39.27 | R-RS-LM0.13
103521 | 1.S mezipatro | K09.103521 | 1.S mezipatro | 39.27 | R-RS-LM0.13
103523 | 1.S mezipatro | K09.103523 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103527 | 1.S mezipatro | K09.103527 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103532 | 1.S mezipatro | K09.103532 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103534 | 1.S mezipatro | K09.103534 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103541 | 1.S mezipatro | K09.103541 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103550 | 1.S mezipatro | K09.103550 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103552 | 1.S mezipatro | K09.103552 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103555 | 1.S mezipatro | K09.103555 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103561 | 1.S | K09.103561 | 1.S | 78.54 | R-RS-LM0.13
103564 | 1.S | K09.103564 | 1.S | 78.54 | R-RS-LM0.13
103567 | 1.S | K09.103567 | 1.S | 78.54 | R-RS-LM0.13
103574 | 1.S | K09.103574 | 1.S | 78.54 | R-RS-LM0.13
103577 | 1.S mezipatro | K09.103577 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103579 | 1.S mezipatro | K09.103579 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103583 | 1.S mezipatro | K09.103583 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103588 | 1.S mezipatro | K09.103588 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103590 | 1.S mezipatro | K09.103590 | 1.S mezipatro | 39.27 | R-RS-LM0.13
103592 | 1.S mezipatro | K09.103592 | 1.S mezipatro | 39.27 | R-RS-LM0.13
103594 | 1.S mezipatro | K09.103594 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103601 | 1.S mezipatro | K09.103601 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103603 | 1.S mezipatro | K09.103603 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103625 | 1.S mezipatro | K09.103625 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103638 | 1.S mezipatro | K09.103638 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103641 | 1.S mezipatro | K09.103641 | 1.S mezipatro | 8.73 | R-RS-LM0.13
103644 | 1.S mezipatro | K09.103644 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103647 | 1.S mezipatro | K09.103647 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103651 | 1.S mezipatro | K09.103651 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103660 | 1.S mezipatro | K09.103660 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103662 | 1.S mezipatro | K09.103662 | 1.S mezipatro | 8.3 | R-RS-LM0.13
103665 | 1.S mezipatro | K09.103665 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103668 | 1.S mezipatro | K09.103668 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103671 | 1.S mezipatro | K09.103671 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103674 | 1.S mezipatro | K09.103674 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103677 | 1.S mezipatro | K09.103677 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103983 | 1.S mezipatro | K09.103983 | 1.S mezipatro | 78.54 | R-RS-LM0.13
103985 | 1.S mezipatro | K09.103985 | 1.S mezipatro | 78.54 | R-RS-LM0.13
119534 | 3.NP mezipatro | K09.119534 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
119536 | 3.NP mezipatro | K09.119536 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
119561 | 3.NP | K09.119561 | 3.NP | 78.54 | R-RS-LM3.13
119564 | 3.NP | K09.119564 | 3.NP | 78.54 | R-RS-LM3.13
119664 | 3.NP mezipatro | K09.119664 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
119790 | 3.NP mezipatro | K09.119790 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
119793 | 3.NP mezipatro | K09.119793 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
119937 | 3.NP | K09.119937 | 3.NP | 78.54 | R-RS-LM3.14
119940 | 3.NP | K09.119940 | 3.NP | 78.54 | R-RS-LM3.14
119961 | 3.NP | K09.119961 | 3.NP | 78.54 | R-RS-LM3.14
119963 | 3.NP | K09.119963 | 3.NP | 78.54 | R-RS-LM3.14
119984 | 3.NP | K09.119984 | 3.NP | 78.54 | R-RS-LM3.14
120002 | 3.NP | K09.120002 | 3.NP | 78.54 | R-RS-LM3.14
120005 | 3.NP | K09.120005 | 3.NP | 78.54 | R-RS-LM3.14
120223 | 2.NP | K09.120223 | 2.NP | 78.54 | R-RS-LM2.13
120226 | 2.NP | K09.120226 | 2.NP | 78.54 | R-RS-LM2.13
120247 | 2.NP mezipatro | K09.120247 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
120250 | 1.S | K09.120250 | 1.S | 78.54 | R-RS-LM2.04
120407 | 1.NP mezipatro | K09.120407 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
120435 | 1.NP | K09.120435 | 1.NP | 78.54 | R-RS-LM1.13
120438 | 1.NP | K09.120438 | 1.NP | 78.54 | R-RS-LM1.13
120589 | 1.S mezipatro | K09.120589 | 1.S mezipatro | 78.54 | R-RS-LM0.12
120592 | 1.S mezipatro | K09.120592 | 1.S mezipatro | 78.54 | R-RS-LM0.12
120607 | 1.S mezipatro | K09.120607 | 1.S mezipatro | 78.54 | R-RS-LM0.12
120610 | 1.S | K09.120610 | 1.S | 78.54 | R-RS-LM0.12
120662 | 1.S | K09.120662 | 1.S | 78.54 | R-RS-LM0.13
120665 | 3.NP mezipatro | K09.120665 | 3.NP mezipatro | 78.54 | R-RS-LM0.13
121255 | 1.S | K09.121255 | 1.S | 78.54 | R-RS-LM1.06
121258 | 3.NP mezipatro | K09.121258 | 3.NP mezipatro | 78.54 | R-RS-LM1.06
121313 | 1.S | K09.121313 | 1.S | 78.54 | R-RS-LM1.05
121316 | 1.S mezipatro | K09.121316 | 1.S mezipatro | 78.54 | R-RS-LM1.05
121384 | 1.S | K09.121384 | 1.S | 78.54 | R-RS-LM2.03
121387 | 3.NP mezipatro | K09.121387 | 3.NP mezipatro | 78.54 | R-RS-LM2.03
121633 | 1.S | K09.121633 | 1.S | 78.54 | R-RS-LM3.03
121636 | 3.NP mezipatro | K09.121636 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
121724 | 1.S | K09.121724 | 1.S | 78.54 | R-RS-LM4.04
121727 | 1.S | K09.121727 | 1.S | 78.54 | R-RS-LM4.04
121747 | 1.S | K09.121747 | 1.S | 78.54 | R-RS-LM4.03
121749 | 3.NP mezipatro | K09.121749 | 3.NP mezipatro | 78.54 | R-RS-LM4.03
125695 | 4.NP mezipatro | K09.125695 | 4.NP mezipatro | 39.27 | R-RS-LM4.04
125702 | 4.NP mezipatro | K09.125702 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
125704 | 4.NP mezipatro | K09.125704 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
125782 | 4.NP mezipatro | K09.125782 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
125785 | 4.NP mezipatro | K09.125785 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
125846 | 4.NP mezipatro | K09.125846 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
125849 | 4.NP mezipatro | K09.125849 | 4.NP mezipatro | 39.27 | R-RS-LM4.04
125857 | 4.NP mezipatro | K09.125857 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
125860 | 4.NP mezipatro | K09.125860 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
126070 | 4.NP mezipatro | K09.126070 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
126075 | 4.NP mezipatro | K09.126075 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
126079 | 4.NP mezipatro | K09.126079 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
126137 | 4.NP mezipatro | K09.126137 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
126179 | 3.NP mezipatro | K09.126179 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
126182 | 3.NP mezipatro | K09.126182 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
126348 | 3.NP mezipatro | K09.126348 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
126420 | 3.NP mezipatro | K09.126420 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
126423 | 3.NP mezipatro | K09.126423 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
126426 | 3.NP mezipatro | K09.126426 | 3.NP mezipatro | 78.54 | R-RS-LM3.03
126553 | 3.NP mezipatro | K09.126553 | 3.NP mezipatro | 78.54 | R-RS-LM4.14
126556 | 4.NP | K09.126556 | 4.NP | 78.54 | R-RS-LM4.14
126702 | 4.NP | K09.126702 | 4.NP | 78.54 | R-RS-LM4.14
126903 | 3.NP mezipatro | K09.126903 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
126906 | 3.NP mezipatro | K09.126906 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127061 | 3.NP mezipatro | K09.127061 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127064 | 3.NP mezipatro | K09.127064 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127081 | 3.NP mezipatro | K09.127081 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127101 | 3.NP mezipatro | K09.127101 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127106 | 3.NP mezipatro | K09.127106 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127109 | 3.NP mezipatro | K09.127109 | 3.NP mezipatro | 78.54 | R-RS-LM3.04
127168 | 3.NP | K09.127168 | 3.NP | 78.54 | R-RS-LM3.14
127171 | 3.NP | K09.127171 | 3.NP | 78.54 | R-RS-LM3.14
127173 | 3.NP | K09.127173 | 3.NP | 78.54 | R-RS-LM3.14
127182 | 3.NP | K09.127182 | 3.NP | 78.54 | R-RS-LM3.14
127185 | 3.NP | K09.127185 | 3.NP | 78.54 | R-RS-LM3.14
127190 | 3.NP | K09.127190 | 3.NP | 78.54 | R-RS-LM3.14
127212 | 3.NP | K09.127212 | 3.NP | 78.54 | R-RS-LM3.14
127217 | 3.NP | K09.127217 | 3.NP | 78.54 | R-RS-LM3.14
127220 | 3.NP | K09.127220 | 3.NP | 78.54 | R-RS-LM3.14
127301 | 2.NP mezipatro | K09.127301 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127304 | 2.NP mezipatro | K09.127304 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127455 | 2.NP mezipatro | K09.127455 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127458 | 2.NP mezipatro | K09.127458 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127483 | 2.NP mezipatro | K09.127483 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127501 | 2.NP mezipatro | K09.127501 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127503 | 2.NP mezipatro | K09.127503 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
127659 | 4.NP | K09.127659 | 4.NP | 78.54 | R-RS-LM4.14
127662 | 4.NP | K09.127662 | 4.NP | 78.54 | R-RS-LM4.14
127672 | 4.NP | K09.127672 | 4.NP | 78.54 | R-RS-LM4.14
127675 | 4.NP | K09.127675 | 4.NP | 78.54 | R-RS-LM4.14
127681 | 4.NP | K09.127681 | 4.NP | 78.54 | R-RS-LM4.14
127684 | 4.NP | K09.127684 | 4.NP | 78.54 | R-RS-LM4.14
127686 | 4.NP | K09.127686 | 4.NP | 78.54 | R-RS-LM4.14
127837 | 4.NP | K09.127837 | 4.NP | 78.54 | R-RS-LM4.13
127842 | 4.NP | K09.127842 | 4.NP | 78.54 | R-RS-LM4.13
127845 | 4.NP | K09.127845 | 4.NP | 78.54 | R-RS-LM4.13
127953 | 4.NP | K09.127953 | 4.NP | 78.54 | R-RS-LM4.13
127958 | 4.NP | K09.127958 | 4.NP | 78.54 | R-RS-LM4.13
127961 | 4.NP | K09.127961 | 4.NP | 78.54 | R-RS-LM4.13
128068 | 4.NP | K09.128068 | 4.NP | 78.54 | R-RS-LM4.13
128071 | 4.NP | K09.128071 | 4.NP | 78.54 | R-RS-LM4.13
128136 | 3.NP | K09.128136 | 3.NP | 78.54 | R-RS-LM3.13
128139 | 3.NP | K09.128139 | 3.NP | 78.54 | R-RS-LM3.13
128169 | 3.NP | K09.128169 | 3.NP | 78.54 | R-RS-LM3.13
128172 | 3.NP | K09.128172 | 3.NP | 78.54 | R-RS-LM3.13
128270 | 3.NP | K09.128270 | 3.NP | 78.54 | R-RS-LM3.13
128273 | 3.NP | K09.128273 | 3.NP | 78.54 | R-RS-LM3.13
128278 | 3.NP | K09.128278 | 3.NP | 78.54 | R-RS-LM3.13
128365 | 3.NP | K09.128365 | 3.NP | 78.54 | R-RS-LM3.13
128368 | 3.NP | K09.128368 | 3.NP | 78.54 | R-RS-LM3.13
128422 | 2.NP | K09.128422 | 2.NP | 78.54 | R-RS-LM2.14
128427 | 2.NP | K09.128427 | 2.NP | 78.54 | R-RS-LM2.14
128430 | 2.NP | K09.128430 | 2.NP | 78.54 | R-RS-LM2.14
128569 | 2.NP | K09.128569 | 2.NP | 78.54 | R-RS-LM2.13
128574 | 2.NP | K09.128574 | 2.NP | 78.54 | R-RS-LM2.13
128577 | 2.NP | K09.128577 | 2.NP | 78.54 | R-RS-LM2.13
128639 | 2.NP | K09.128639 | 2.NP | 78.54 | R-RS-LM2.13
128644 | 2.NP | K09.128644 | 2.NP | 78.54 | R-RS-LM2.13
128647 | 2.NP | K09.128647 | 2.NP | 78.54 | R-RS-LM2.13
128727 | 2.NP | K09.128727 | 2.NP | 78.54 | R-RS-LM2.13
128734 | 2.NP | K09.128734 | 2.NP | 78.54 | R-RS-LM2.13
128737 | 2.NP | K09.128737 | 2.NP | 78.54 | R-RS-LM2.13
128769 | 2.NP | K09.128769 | 2.NP | 78.54 | R-RS-LM2.13
128772 | 2.NP | K09.128772 | 2.NP | 78.54 | R-RS-LM2.13
128916 | 2.NP mezipatro | K09.128916 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
128959 | 2.NP mezipatro | K09.128959 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
128964 | 2.NP mezipatro | K09.128964 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
128967 | 2.NP mezipatro | K09.128967 | 2.NP mezipatro | 78.54 | R-RS-LM2.03
129010 | 1.NP | K09.129010 | 1.NP | 78.54 | R-RS-LM1.14
129018 | 1.NP | K09.129018 | 1.NP | 78.54 | R-RS-LM1.14
129080 | 1.NP | K09.129080 | 1.NP | 78.54 | R-RS-LM1.14
129092 | 1.NP | K09.129092 | 1.NP | 78.54 | R-RS-LM1.14
129095 | 1.NP | K09.129095 | 1.NP | 78.54 | R-RS-LM1.14
129186 | 1.NP | K09.129186 | 1.NP | 78.54 | R-RS-LM1.14
129189 | 1.NP | K09.129189 | 1.NP | 78.54 | R-RS-LM1.14
129300 | 1.NP | K09.129300 | 1.NP | 78.54 | R-RS-LM1.14
129305 | 1.NP | K09.129305 | 1.NP | 78.54 | R-RS-LM1.14
129308 | 1.NP | K09.129308 | 1.NP | 78.54 | R-RS-LM1.14
129438 | 1.NP | K09.129438 | 1.NP | 78.54 | R-RS-LM1.13
129443 | 1.NP | K09.129443 | 1.NP | 78.54 | R-RS-LM1.13
129446 | 1.NP | K09.129446 | 1.NP | 78.54 | R-RS-LM1.13
129532 | 1.NP | K09.129532 | 1.NP | 78.54 | R-RS-LM1.13
129537 | 1.NP | K09.129537 | 1.NP | 78.54 | R-RS-LM1.13
129540 | 1.NP | K09.129540 | 1.NP | 78.54 | R-RS-LM1.13
129572 | 1.NP | K09.129572 | 1.NP | 78.54 | R-RS-LM1.13
