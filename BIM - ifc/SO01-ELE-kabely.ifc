Properties of the parts of a building model (IFC4), part 1 of 7

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: dd9cd7ed-3f16-4289-9850-101312d3c4a0, NumberOfSaves: 357]
File name: C:\Users\Petr.Kadera\Downloads\SO01-ELE-kabely.ifc
Time: 2025-04-17T11:20:24+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (CSY) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:#Hlavní (13)
Name | LongName | Elevation (mm)
1.S | 1.S | 0
1.S mezipatro | 1.S mezipatro | 1500
1.NP | 1.NP | 3000
1.NP mezipatro | 1.NP mezipatro | 4500
2.NP | 2.NP | 6000
2.NP mezipatro | 2.NP mezipatro | 7500
3.NP | 3.NP | 9000
3.NP mezipatro | 3.NP mezipatro | 10500
4.NP | 4.NP | 12000
4.NP mezipatro | 4.NP mezipatro | 13500
5.NP | 5.NP | 15000
5.NP mezipatro | 5.NP mezipatro | 16500
Střecha | Střecha | 20120

# IfcCableCarrierFitting: #Elektroinstalační trubka, T spojka:#Elektroinstalační trubka, T spojka (331)
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Elektroinstalační trubka, T spojka; ElementProjectSpecificIdentifier: KX01; ElementProjectSpecificDescription: Spojka
Name (#Elektroinstalační trubka, T spojka:#Elektroinstalační trubka, T spojka:...) | In
41068 | 1.S
41159 | 1.S
42785 | 1.S
50588 | 4.NP
50671 | 4.NP
50791 | 4.NP
50872 | 4.NP
50948 | 4.NP
51021 | 4.NP
52276 | 4.NP
52336 | 4.NP
52460 | 4.NP
53984 | 4.NP
54336 | 4.NP
55445 | 4.NP
55462 | 4.NP
55479 | 4.NP
55496 | 4.NP
55513 | 4.NP
55775 | 4.NP
56085 | 4.NP mezipatro
56118 | 4.NP mezipatro
56602 | 2.NP mezipatro
56610 | 2.NP mezipatro
57393 | 1.S mezipatro
57401 | 1.S mezipatro
57792 | 4.NP mezipatro
57939 | 4.NP mezipatro
59790 | 2.NP
59796 | 2.NP
59813 | 2.NP
59822 | 2.NP
59830 | 2.NP
60149 | 2.NP
64769 | 4.NP
65802 | 2.NP mezipatro
65878 | 2.NP mezipatro
66122 | 2.NP mezipatro
66715 | 4.NP
66992 | 4.NP mezipatro
67063 | 4.NP mezipatro
67172 | 4.NP mezipatro
67187 | 4.NP mezipatro
67196 | 4.NP mezipatro
67205 | 4.NP mezipatro
67214 | 4.NP mezipatro
67383 | 1.S
67655 | 1.S
68850 | 1.S
69146 | 1.S
69257 | 1.NP
69504 | 5.NP mezipatro
69518 | 4.NP mezipatro
69526 | 4.NP
69534 | 3.NP mezipatro
69542 | 3.NP
69550 | 2.NP mezipatro
69558 | 2.NP
69566 | 1.NP mezipatro
69954 | 1.S
69983 | 1.S
69999 | 1.S
70031 | 1.S
70048 | 1.S
70065 | 1.S
70076 | 1.S
70728 | 1.S mezipatro
70807 | 1.S mezipatro
71023 | 1.S mezipatro
71125 | 1.S mezipatro
71227 | 4.NP mezipatro
71289 | 4.NP mezipatro
71312 | 4.NP mezipatro
71339 | 4.NP mezipatro
71423 | 1.NP mezipatro
71431 | 1.NP mezipatro
71516 | 1.NP mezipatro
71528 | 1.NP mezipatro
71565 | 1.NP mezipatro
71971 | 4.NP mezipatro
72002 | 4.NP mezipatro
72025 | 4.NP mezipatro
72049 | 4.NP mezipatro
72313 | 1.NP
72323 | 1.S mezipatro
72334 | 1.NP mezipatro
72344 | 2.NP
72355 | 2.NP mezipatro
72365 | 3.NP
72375 | 3.NP mezipatro
72402 | 4.NP
72441 | 4.NP mezipatro
72639 | 5.NP mezipatro
72893 | 1.S
72981 | 1.S
73005 | 1.S
73029 | 1.S
73046 | 1.S
73063 | 1.S
73080 | 1.S
73487 | 1.S
73890 | 1.S
73943 | 1.S
73955 | 1.S
74339 | 1.NP
74345 | 1.NP
74362 | 1.NP
74371 | 1.NP
74388 | 1.NP
74421 | 1.NP
74703 | 2.NP
75159 | 1.S
75178 | 1.S
75189 | 1.S
75200 | 1.S
75215 | 1.S
75274 | 1.S
75278 | 1.S
75426 | 3.NP mezipatro
75457 | 3.NP mezipatro
75474 | 3.NP mezipatro
75518 | 3.NP mezipatro
76239 | 1.S
76313 | 1.S
76331 | 1.S mezipatro
76341 | 1.NP mezipatro
76380 | 4.NP mezipatro
76387 | 3.NP mezipatro
76394 | 2.NP mezipatro
76406 | 4.NP
76414 | 3.NP
76422 | 2.NP
76430 | 1.NP
76511 | 3.NP mezipatro
76519 | 3.NP mezipatro
76585 | 3.NP mezipatro
76594 | 3.NP mezipatro
76622 | 3.NP mezipatro
77269 | 1.NP
77274 | 1.S mezipatro
77281 | 1.NP mezipatro
77287 | 2.NP
77294 | 2.NP mezipatro
77300 | 3.NP
77306 | 3.NP mezipatro
77312 | 4.NP
77318 | 4.NP mezipatro
77329 | 5.NP mezipatro
78364 | 1.S mezipatro
78384 | 1.S mezipatro
78404 | 1.S mezipatro
78424 | 1.S mezipatro
78444 | 1.S mezipatro
78473 | 1.S mezipatro
78498 | 1.S mezipatro
78515 | 1.S mezipatro
78885 | 1.NP mezipatro
78925 | 1.NP mezipatro
78942 | 1.NP mezipatro
78976 | 1.NP mezipatro
78993 | 1.NP mezipatro
79183 | 1.NP mezipatro
79387 | 1.NP mezipatro
81321 | 1.S
82543 | 1.S
85134 | 1.S
86097 | 5.NP
86405 | 1.S mezipatro
86417 | 1.NP mezipatro
86429 | 2.NP mezipatro
86441 | 3.NP mezipatro
87217 | 4.NP
88464 | 1.S
88473 | 1.S mezipatro
88480 | 1.NP
88487 | 1.NP mezipatro
88494 | 2.NP
88501 | 2.NP mezipatro
88508 | 3.NP
88515 | 3.NP mezipatro
88522 | 4.NP
88529 | 4.NP
89319 | 4.NP
89331 | 4.NP
89859 | 1.NP
89868 | 1.NP
89877 | 1.NP
89901 | 1.NP
89969 | 1.NP
89980 | 1.NP
90011 | 1.NP
90014 | 1.NP
90563 | 1.NP
90671 | 2.NP
90680 | 2.NP
90704 | 2.NP
90769 | 2.NP
90780 | 2.NP
90811 | 2.NP
90814 | 2.NP
91348 | 2.NP
91795 | Střecha
91964 | 4.NP
92086 | 3.NP
92167 | 3.NP
92178 | 3.NP
92250 | 3.NP
93264 | 5.NP
93626 | 5.NP
94993 | 5.NP
95031 | 5.NP
96075 | 5.NP
96088 | 5.NP
96160 | 5.NP
96170 | 5.NP
96677 | 1.S
97230 | 1.S
97346 | 1.S
97385 | 1.S
97424 | 1.S
99450 | 1.NP mezipatro
99467 | 1.NP mezipatro
99476 | 1.NP mezipatro
99482 | 1.NP mezipatro
99488 | 1.NP mezipatro
99494 | 1.NP mezipatro
99679 | 1.NP mezipatro
100879 | 2.NP mezipatro
100919 | 2.NP mezipatro
100936 | 2.NP mezipatro
100970 | 2.NP mezipatro
100987 | 2.NP mezipatro
101024 | 2.NP mezipatro
101046 | 2.NP mezipatro
101882 | 3.NP mezipatro
101893 | 3.NP mezipatro
102161 | 1.NP
102169 | 1.NP
102177 | 1.NP
102185 | 1.NP
102193 | 1.NP
102201 | 1.NP
102218 | 1.NP
102307 | 2.NP
102312 | 2.NP
102318 | 2.NP
102324 | 2.NP
102330 | 2.NP
102336 | 2.NP
102627 | 3.NP
102633 | 3.NP
102650 | 3.NP
102659 | 3.NP
102667 | 3.NP
102696 | 3.NP
102703 | 3.NP
103035 | 2.NP mezipatro
103051 | 2.NP mezipatro
103060 | 2.NP mezipatro
103066 | 2.NP mezipatro
103072 | 2.NP mezipatro
103078 | 2.NP mezipatro
103204 | 2.NP mezipatro
103230 | 3.NP mezipatro
103246 | 3.NP mezipatro
103260 | 3.NP mezipatro
103266 | 3.NP mezipatro
103272 | 3.NP mezipatro
103293 | 3.NP mezipatro
103490 | 1.S mezipatro
103499 | 1.S mezipatro
103530 | 1.S mezipatro
103547 | 1.S mezipatro
103581 | 1.S mezipatro
103598 | 1.S mezipatro
103635 | 1.S mezipatro
103657 | 1.S mezipatro
104042 | 1.NP
104059 | 2.NP
104129 | 3.NP
104134 | 3.NP
104140 | 3.NP
104146 | 3.NP
104152 | 3.NP
104203 | 3.NP
104263 | 3.NP
104326 | 3.NP
106837 | 4.NP
106949 | 5.NP
106969 | 5.NP
106982 | 5.NP
119698 | 3.NP mezipatro
119783 | 3.NP mezipatro
119947 | 3.NP
119956 | 3.NP
119995 | 3.NP
120010 | 3.NP
127092 | 3.NP mezipatro
127496 | 2.NP mezipatro
127667 | 4.NP
128952 | 2.NP mezipatro
129646 | 1.NP mezipatro
130187 | 1.NP mezipatro
131506 | 1.S
131601 | 1.S
132249 | 1.S
132277 | 1.S
133687 | 1.S
133936 | 1.NP mezipatro
134240 | 2.NP mezipatro
134354 | 2.NP
134544 | 3.NP mezipatro
189086 | 1.S
189105 | 1.S
190654 | 1.S
193500 | 1.S
193653 | 1.S
202800 | 2.NP mezipatro
202992 | 3.NP mezipatro
203056 | 1.NP mezipatro
203100 | 1.S mezipatro
203455 | 1.S
203734 | 4.NP mezipatro
204022 | 1.S
204746 | 1.S
204927 | 1.S
206770 | 1.S
207296 | 1.S mezipatro
207491 | 1.S
207728 | 1.S
232317 | 5.NP

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:2xCXKH-V-J 5x10 (4)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 2xCXKH-V-J 5x10; ElementProjectSpecificDescription: 2xCXKH-V-J 5x10; ElementProjectSpecificIdentifier: K01; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: 2xCXKH-V-J 5x10
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RPO
Name (#Elektroinstalační trubka, koleno:2xCXKH-V-J 5x10:...) | Reference
116548 | K01.116548
116550 | K01.116550
116553 | K01.116553
116557 | K01.116557

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:2xCYKY-J 3x120+70 + CYA25ZŽ (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 2xCYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificDescription: 2xCYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificIdentifier: K02; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: 2xCYKY-J 3x120+70 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:2xCYKY-J 3x120+70 + CYA25ZŽ:...) | Reference
115106 | K02.115106
115109 | K02.115109

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:2xCYY-J 4x150 (6)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: 2xCYY-J 4x150; ElementProjectSpecificDescription: 2xCYY-J 4x150; ElementProjectSpecificIdentifier: K03; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: 2xCYY-J 4x150
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: Trafo
Name (#Elektroinstalační trubka, koleno:2xCYY-J 4x150:...) | Reference
113752 | K03.113752
113754 | K03.113754
113757 | K03.113757
113761 | K03.113761
113767 | K03.113767
113928 | K03.113928

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CXKH-V-J 3x1,5 (421)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 3x1,5; ElementProjectSpecificDescription: CXKH-V-J 3x1,5; ElementProjectSpecificIdentifier: K04; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 3x1,5
Pset_DistributionSystemCommon - Reference: RPO
Name (#Elektroinstalační trubka, koleno:CXKH-V-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
55258 | 1.S | K04.55258 | 1.S | 78.54 | RPO-N4.11
55261 | 1.S | K04.55261 | 1.S | 78.54 | RPO-N4.11
55449 | 4.NP | K04.55449 | 4.NP | 78.54 | RPO-N4.11
55466 | 4.NP | K04.55466 | 4.NP | 78.54 | RPO-N4.11
55483 | 4.NP | K04.55483 | 4.NP | 78.54 | RPO-N4.11
55500 | 4.NP | K04.55500 | 4.NP | 78.54 | RPO-N4.11
55517 | 4.NP | K04.55517 | 4.NP | 78.54 | RPO-N4.11
55888 | 4.NP | K04.55888 | 4.NP | 8.25 | RPO-N4.11
55891 | 4.NP | K04.55891 | 4.NP | 78.54 | RPO-N4.11
58005 | 1.S | K04.58005 | 1.S | 78.54 | RPO-N4.01
58036 | 1.S | K04.58036 | 1.S | 78.54 | RPO-N4.01
64354 | 4.NP | K04.64354 | 4.NP | 78.54 | RPO-N4.11
64680 | 4.NP | K04.64680 | 4.NP | 78.54 | RPO-N4.11
64682 | 4.NP | K04.64682 | 4.NP | 39.27 | RPO-N4.11
64684 | 4.NP | K04.64684 | 4.NP | 39.27 | RPO-N4.11
64773 | 4.NP | K04.64773 | 4.NP | 78.54 | RPO-N4.11
66802 | 4.NP mezipatro | K04.66802 | 4.NP mezipatro | 78.54 | RPO-N4.01
66804 | 4.NP mezipatro | K04.66804 | 4.NP mezipatro | 78.54 | RPO-N4.01
66914 | 4.NP mezipatro | K04.66914 | 4.NP mezipatro | 78.54 | RPO-N4.01
66916 | 4.NP mezipatro | K04.66916 | 4.NP mezipatro | 39.27 | RPO-N4.01
66918 | 4.NP mezipatro | K04.66918 | 4.NP mezipatro | 39.27 | RPO-N4.01
66945 | 4.NP mezipatro | K04.66945 | 4.NP mezipatro | 78.54 | RPO-N4.01
66997 | 4.NP mezipatro | K04.66997 | 4.NP mezipatro | 78.54 | RPO-N4.01
67069 | 4.NP mezipatro | K04.67069 | 4.NP mezipatro | 78.54 | RPO-N4.01
67179 | 4.NP mezipatro | K04.67179 | 4.NP mezipatro | 78.54 | RPO-N4.01
67182 | 4.NP mezipatro | K04.67182 | 4.NP mezipatro | 78.54 | RPO-N4.01
67191 | 4.NP mezipatro | K04.67191 | 4.NP mezipatro | 78.54 | RPO-N4.01
67200 | 4.NP mezipatro | K04.67200 | 4.NP mezipatro | 78.54 | RPO-N4.01
67209 | 4.NP mezipatro | K04.67209 | 4.NP mezipatro | 78.54 | RPO-N4.01
67218 | 4.NP mezipatro | K04.67218 | 4.NP mezipatro | 78.54 | RPO-N4.01
68984 | 1.S | K04.68984 | 1.S | 78.54 | RPO-N0.01
68997 | 1.S | K04.68997 | 1.S | 78.54 | RPO-N0.01
69021 | 1.S | K04.69021 | 1.S | 78.54 | RPO-N0.01
69023 | 1.S | K04.69023 | 1.S | 39.27 | RPO-N0.01
69025 | 1.S | K04.69025 | 1.S | 39.27 | RPO-N0.01
69056 | 1.S | K04.69056 | 1.S | 78.54 | RPO-N0.01
69058 | 1.S | K04.69058 | 1.S | 78.54 | RPO-N0.01
69152 | 1.S mezipatro | K04.69152 | 1.S mezipatro | 78.54 | RPO-N0.01
69262 | 1.NP | K04.69262 | 1.NP | 78.54 | RPO-N0.01
69459 | 5.NP mezipatro | K04.69459 | 5.NP mezipatro | 78.54 | RPO-N0.01
69501 | 5.NP mezipatro | K04.69501 | 5.NP mezipatro | 78.54 | RPO-N0.01
69523 | 4.NP mezipatro | K04.69523 | 4.NP mezipatro | 78.54 | RPO-N0.01
69531 | 4.NP | K04.69531 | 4.NP | 78.54 | RPO-N0.01
69539 | 3.NP mezipatro | K04.69539 | 3.NP mezipatro | 78.54 | RPO-N0.01
69547 | 3.NP | K04.69547 | 3.NP | 78.54 | RPO-N0.01
69555 | 2.NP mezipatro | K04.69555 | 2.NP mezipatro | 78.54 | RPO-N0.01
69563 | 2.NP | K04.69563 | 2.NP | 78.54 | RPO-N0.01
69571 | 1.NP mezipatro | K04.69571 | 1.NP mezipatro | 78.54 | RPO-N0.01
69852 | 1.S | K04.69852 | 1.S | 78.54 | RPO-N0.01
72083 | 1.S mezipatro | K04.72083 | 1.S mezipatro | 78.54 | RPO-N0.02
72087 | 1.NP | K04.72087 | 1.NP | 78.54 | RPO-N0.02
72106 | 4.NP mezipatro | K04.72106 | 4.NP mezipatro | 78.54 | RPO-N0.02
72109 | 4.NP | K04.72109 | 4.NP | 78.54 | RPO-N0.02
72112 | 3.NP mezipatro | K04.72112 | 3.NP mezipatro | 78.54 | RPO-N0.02
72115 | 3.NP | K04.72115 | 3.NP | 78.54 | RPO-N0.02
72118 | 2.NP mezipatro | K04.72118 | 2.NP mezipatro | 78.54 | RPO-N0.02
72120 | 1.NP mezipatro | K04.72120 | 1.NP mezipatro | 78.54 | RPO-N0.02
72160 | 1.S mezipatro | K04.72160 | 1.S mezipatro | 78.54 | RPO-N0.02
72185 | 1.NP | K04.72185 | 1.NP | 78.54 | RPO-N0.02
72191 | 1.NP mezipatro | K04.72191 | 1.NP mezipatro | 78.54 | RPO-N0.02
72193 | 2.NP | K04.72193 | 2.NP | 78.54 | RPO-N0.02
72200 | 2.NP | K04.72200 | 2.NP | 78.54 | RPO-N0.02
72206 | 2.NP mezipatro | K04.72206 | 2.NP mezipatro | 78.54 | RPO-N0.02
72213 | 3.NP | K04.72213 | 3.NP | 78.54 | RPO-N0.02
72219 | 3.NP mezipatro | K04.72219 | 3.NP mezipatro | 78.54 | RPO-N0.02
72225 | 4.NP | K04.72225 | 4.NP | 78.54 | RPO-N0.02
72231 | 4.NP mezipatro | K04.72231 | 4.NP mezipatro | 78.54 | RPO-N0.02
72246 | 1.S | K04.72246 | 1.S | 78.54 | RPO-N0.02
72316 | 1.NP | K04.72316 | 1.NP | 78.54 | RPO-N0.02
72327 | 1.S mezipatro | K04.72327 | 1.S mezipatro | 78.54 | RPO-N0.02
72338 | 1.NP mezipatro | K04.72338 | 1.NP mezipatro | 78.54 | RPO-N0.02
72348 | 2.NP | K04.72348 | 2.NP | 78.54 | RPO-N0.02
72359 | 2.NP mezipatro | K04.72359 | 2.NP mezipatro | 78.54 | RPO-N0.02
72369 | 3.NP | K04.72369 | 3.NP | 78.54 | RPO-N0.02
72379 | 3.NP mezipatro | K04.72379 | 3.NP mezipatro | 78.54 | RPO-N0.02
72407 | 4.NP | K04.72407 | 4.NP | 78.54 | RPO-N0.02
72446 | 4.NP mezipatro | K04.72446 | 4.NP mezipatro | 78.54 | RPO-N0.02
72617 | 5.NP mezipatro | K04.72617 | 5.NP mezipatro | 78.54 | RPO-N0.02
72620 | 5.NP mezipatro | K04.72620 | 5.NP mezipatro | 78.54 | RPO-N0.02
72672 | 5.NP | K04.72672 | 5.NP | 78.54 | RPO-N0.02
72675 | 5.NP | K04.72675 | 5.NP | 78.54 | RPO-N0.02
72923 | 1.S | K04.72923 | 1.S | 78.54 | RPO-N0.03
72957 | 1.S | K04.72957 | 1.S | 78.54 | RPO-N0.03
72959 | 1.S | K04.72959 | 1.S | 39.27 | RPO-N0.03
72961 | 1.S | K04.72961 | 1.S | 39.27 | RPO-N0.03
72985 | 1.S | K04.72985 | 1.S | 78.54 | RPO-N0.03
73009 | 1.S | K04.73009 | 1.S | 78.54 | RPO-N0.03
73033 | 1.S | K04.73033 | 1.S | 78.54 | RPO-N0.03
73050 | 1.S | K04.73050 | 1.S | 78.54 | RPO-N0.03
73067 | 1.S | K04.73067 | 1.S | 78.54 | RPO-N0.03
73456 | 1.S | K04.73456 | 1.S | 11.65 | RPO-N0.03
73492 | 1.S | K04.73492 | 1.S | 78.54 | RPO-N0.03
73516 | 1.S | K04.73516 | 1.S | 78.54 | RPO-N0.03
73518 | 1.S | K04.73518 | 1.S | 39.27 | RPO-N0.03
73520 | 1.S | K04.73520 | 1.S | 39.27 | RPO-N0.03
73685 | 1.S | K04.73685 | 1.S | 8.6 | RPO-N0.03
73838 | 1.S | K04.73838 | 1.S | 78.54 | RPO-N0.03
73874 | 1.S | K04.73874 | 1.S | 11.65 | RPO-N0.03
73895 | 1.S | K04.73895 | 1.S | 78.54 | RPO-N0.03
73949 | 1.S | K04.73949 | 1.S | 78.54 | RPO-N0.03
73961 | 1.S | K04.73961 | 1.S | 78.54 | RPO-N0.03
75145 | 1.S | K04.75145 | 1.S | 78.54 | RPO-N0.04
75182 | 1.S | K04.75182 | 1.S | 78.54 | RPO-N0.04
75193 | 1.S | K04.75193 | 1.S | 78.54 | RPO-N0.04
75204 | 1.S | K04.75204 | 1.S | 78.54 | RPO-N0.04
75208 | 1.S | K04.75208 | 1.S | 78.54 | RPO-N0.04
75219 | 1.S | K04.75219 | 1.S | 78.54 | RPO-N0.04
75225 | 1.S | K04.75225 | 1.S | 78.54 | RPO-N0.04
75256 | 1.S | K04.75256 | 1.S | 78.54 | RPO-N0.04
75261 | 1.S | K04.75261 | 1.S | 78.54 | RPO-N0.04
76213 | 1.S | K04.76213 | 1.S | 78.54 | RPO-N0.05
76243 | 1.S | K04.76243 | 1.S | 78.54 | RPO-N0.05
76245 | 1.S | K04.76245 | 1.S | 78.54 | RPO-N0.05
76252 | 1.S | K04.76252 | 1.S | 78.54 | RPO-N0.05
76302 | 1.S | K04.76302 | 1.S | 78.54 | RPO-N0.05
76308 | 1.S mezipatro | K04.76308 | 1.S mezipatro | 78.54 | RPO-N0.05
76311 | 1.S | K04.76311 | 1.S | 78.54 | RPO-N0.05
76321 | 1.S mezipatro | K04.76321 | 1.S mezipatro | 78.54 | RPO-N0.05
76326 | 1.S mezipatro | K04.76326 | 1.S mezipatro | 78.54 | RPO-N0.05
76345 | 1.NP mezipatro | K04.76345 | 1.NP mezipatro | 78.54 | RPO-N0.05
76375 | 5.NP mezipatro | K04.76375 | 5.NP mezipatro | 78.54 | RPO-N0.05
76377 | 5.NP mezipatro | K04.76377 | 5.NP mezipatro | 78.54 | RPO-N0.05
76384 | 4.NP mezipatro | K04.76384 | 4.NP mezipatro | 78.54 | RPO-N0.05
76391 | 3.NP mezipatro | K04.76391 | 3.NP mezipatro | 78.54 | RPO-N0.05
76398 | 2.NP mezipatro | K04.76398 | 2.NP mezipatro | 78.54 | RPO-N0.05
76401 | 5.NP | K04.76401 | 5.NP | 78.54 | RPO-N0.05
76403 | 5.NP | K04.76403 | 5.NP | 78.54 | RPO-N0.05
76410 | 4.NP | K04.76410 | 4.NP | 78.54 | RPO-N0.05
76418 | 3.NP | K04.76418 | 3.NP | 78.54 | RPO-N0.05
76426 | 2.NP | K04.76426 | 2.NP | 78.54 | RPO-N0.05
76434 | 1.NP | K04.76434 | 1.NP | 78.54 | RPO-N0.05
77230 | 3.NP | K04.77230 | 3.NP | 78.54 | RPO-N0.06
77271 | 1.NP | K04.77271 | 1.NP | 78.54 | RPO-N0.06
77277 | 1.S mezipatro | K04.77277 | 1.S mezipatro | 78.54 | RPO-N0.06
77284 | 1.NP mezipatro | K04.77284 | 1.NP mezipatro | 78.54 | RPO-N0.06
77290 | 2.NP | K04.77290 | 2.NP | 78.54 | RPO-N0.06
77297 | 2.NP mezipatro | K04.77297 | 2.NP mezipatro | 78.54 | RPO-N0.06
77303 | 3.NP | K04.77303 | 3.NP | 78.54 | RPO-N0.06
77309 | 3.NP mezipatro | K04.77309 | 3.NP mezipatro | 78.54 | RPO-N0.06
77315 | 4.NP | K04.77315 | 4.NP | 78.54 | RPO-N0.06
77321 | 4.NP mezipatro | K04.77321 | 4.NP mezipatro | 78.54 | RPO-N0.06
77333 | 5.NP | K04.77333 | 5.NP | 78.54 | RPO-N0.06
77335 | 5.NP | K04.77335 | 5.NP | 78.54 | RPO-N0.06
77647 | 1.S | K04.77647 | 1.S | 78.54 | RPO-N0.06
77649 | 1.S | K04.77649 | 1.S | 78.54 | RPO-N0.06
77689 | 1.S mezipatro | K04.77689 | 1.S mezipatro | 78.54 | RPO-N0.06
77699 | 1.S mezipatro | K04.77699 | 1.S mezipatro | 78.54 | RPO-N0.06
77702 | 1.S mezipatro | K04.77702 | 1.S mezipatro | 78.54 | RPO-N0.06
77738 | 1.NP | K04.77738 | 1.NP | 78.54 | RPO-N0.06
77741 | 1.NP | K04.77741 | 1.NP | 78.54 | RPO-N0.06
77749 | 1.NP | K04.77749 | 1.NP | 78.54 | RPO-N0.06
77773 | 2.NP | K04.77773 | 2.NP | 78.54 | RPO-N0.06
77776 | 2.NP | K04.77776 | 2.NP | 78.54 | RPO-N0.06
77784 | 2.NP | K04.77784 | 2.NP | 78.54 | RPO-N0.06
77808 | 3.NP | K04.77808 | 3.NP | 78.54 | RPO-N0.06
77811 | 3.NP | K04.77811 | 3.NP | 78.54 | RPO-N0.06
77844 | 4.NP | K04.77844 | 4.NP | 78.54 | RPO-N0.06
77852 | 4.NP | K04.77852 | 4.NP | 78.54 | RPO-N0.06
77855 | 4.NP | K04.77855 | 4.NP | 78.54 | RPO-N0.06
77886 | 1.NP mezipatro | K04.77886 | 1.NP mezipatro | 78.54 | RPO-N0.06
77892 | 1.NP mezipatro | K04.77892 | 1.NP mezipatro | 78.54 | RPO-N0.06
77895 | 1.NP mezipatro | K04.77895 | 1.NP mezipatro | 78.54 | RPO-N0.06
77933 | 2.NP mezipatro | K04.77933 | 2.NP mezipatro | 78.54 | RPO-N0.06
77941 | 2.NP mezipatro | K04.77941 | 2.NP mezipatro | 78.54 | RPO-N0.06
77944 | 2.NP mezipatro | K04.77944 | 2.NP mezipatro | 78.54 | RPO-N0.06
78001 | 3.NP mezipatro | K04.78001 | 3.NP mezipatro | 78.54 | RPO-N0.06
78009 | 3.NP mezipatro | K04.78009 | 3.NP mezipatro | 78.54 | RPO-N0.06
78012 | 3.NP mezipatro | K04.78012 | 3.NP mezipatro | 78.54 | RPO-N0.06
78054 | 4.NP mezipatro | K04.78054 | 4.NP mezipatro | 78.54 | RPO-N0.06
78062 | 4.NP mezipatro | K04.78062 | 4.NP mezipatro | 78.54 | RPO-N0.06
78065 | 4.NP mezipatro | K04.78065 | 4.NP mezipatro | 78.54 | RPO-N0.06
78122 | 5.NP | K04.78122 | 5.NP | 78.54 | RPO-N0.06
78125 | 5.NP mezipatro | K04.78125 | 5.NP mezipatro | 78.54 | RPO-N0.06
78169 | 5.NP mezipatro | K04.78169 | 5.NP mezipatro | 78.54 | RPO-N0.06
78171 | 5.NP mezipatro | K04.78171 | 5.NP mezipatro | 78.54 | RPO-N0.06
78295 | 1.S mezipatro | K04.78295 | 1.S mezipatro | 78.54 | RPO-N0.11
78335 | 1.S mezipatro | K04.78335 | 1.S mezipatro | 39.27 | RPO-N0.11
78337 | 1.S mezipatro | K04.78337 | 1.S mezipatro | 39.27 | RPO-N0.11
78339 | 1.S mezipatro | K04.78339 | 1.S mezipatro | 78.54 | RPO-N0.11
78370 | 1.S mezipatro | K04.78370 | 1.S mezipatro | 78.54 | RPO-N0.11
78390 | 1.S mezipatro | K04.78390 | 1.S mezipatro | 78.54 | RPO-N0.11
78410 | 1.S mezipatro | K04.78410 | 1.S mezipatro | 78.54 | RPO-N0.11
78430 | 1.S mezipatro | K04.78430 | 1.S mezipatro | 78.54 | RPO-N0.11
78450 | 1.S mezipatro | K04.78450 | 1.S mezipatro | 78.54 | RPO-N0.11
78479 | 1.S mezipatro | K04.78479 | 1.S mezipatro | 78.54 | RPO-N0.11
78481 | 1.S mezipatro | K04.78481 | 1.S mezipatro | 78.54 | RPO-N0.11
78502 | 1.S mezipatro | K04.78502 | 1.S mezipatro | 78.54 | RPO-N0.11
78600 | 1.S mezipatro | K04.78600 | 1.S mezipatro | 8.6 | RPO-N0.11
78602 | 1.S mezipatro | K04.78602 | 1.S mezipatro | 78.54 | RPO-N0.11
78682 | 1.S mezipatro | K04.78682 | 1.S mezipatro | 78.54 | RPO-N0.11
78703 | 1.S mezipatro | K04.78703 | 1.S mezipatro | 78.54 | RPO-N0.11
78769 | 1.S | K04.78769 | 1.S | 78.54 | RPO-N0.11
78837 | 1.S | K04.78837 | 1.S | 11.65 | RPO-N0.11
99413 | 1.S | K04.99413 | 1.S | 78.54 | RPO-N1.01
99420 | 1.S | K04.99420 | 1.S | 78.54 | RPO-N1.01
99423 | 1.NP mezipatro | K04.99423 | 1.NP mezipatro | 78.54 | RPO-N1.01
99425 | 1.NP mezipatro | K04.99425 | 1.NP mezipatro | 78.54 | RPO-N1.01
99440 | 1.NP mezipatro | K04.99440 | 1.NP mezipatro | 78.54 | RPO-N1.01
99453 | 1.NP mezipatro | K04.99453 | 1.NP mezipatro | 78.54 | RPO-N1.01
99470 | 1.NP mezipatro | K04.99470 | 1.NP mezipatro | 78.54 | RPO-N1.01
99473 | 1.NP mezipatro | K04.99473 | 1.NP mezipatro | 78.54 | RPO-N1.01
99479 | 1.NP mezipatro | K04.99479 | 1.NP mezipatro | 78.54 | RPO-N1.01
99485 | 1.NP mezipatro | K04.99485 | 1.NP mezipatro | 78.54 | RPO-N1.01
99491 | 1.NP mezipatro | K04.99491 | 1.NP mezipatro | 78.54 | RPO-N1.01
99497 | 1.NP mezipatro | K04.99497 | 1.NP mezipatro | 78.54 | RPO-N1.01
99683 | 1.NP mezipatro | K04.99683 | 1.NP mezipatro | 78.54 | RPO-N1.01
99685 | 1.NP mezipatro | K04.99685 | 1.NP mezipatro | 8.3 | RPO-N1.01
102112 | 1.NP mezipatro | K04.102112 | 1.NP mezipatro | 78.54 | RPO-N1.01
102114 | 1.NP mezipatro | K04.102114 | 1.NP mezipatro | 39.27 | RPO-N1.01
102116 | 1.NP mezipatro | K04.102116 | 1.NP mezipatro | 39.27 | RPO-N1.01
102127 | 1.NP | K04.102127 | 1.NP | 78.54 | RPO-N1.11
102165 | 1.NP | K04.102165 | 1.NP | 78.54 | RPO-N1.11
102173 | 1.NP | K04.102173 | 1.NP | 78.54 | RPO-N1.11
102181 | 1.NP | K04.102181 | 1.NP | 78.54 | RPO-N1.11
102189 | 1.NP | K04.102189 | 1.NP | 78.54 | RPO-N1.11
102197 | 1.NP | K04.102197 | 1.NP | 78.54 | RPO-N1.11
102205 | 1.NP | K04.102205 | 1.NP | 78.54 | RPO-N1.11
102221 | 1.NP | K04.102221 | 1.NP | 78.54 | RPO-N1.11
102224 | 1.NP | K04.102224 | 1.NP | 78.54 | RPO-N1.11
102228 | 1.S mezipatro | K04.102228 | 1.S mezipatro | 78.54 | RPO-N1.11
102241 | 1.S | K04.102241 | 1.S | 11.65 | RPO-N1.11
102259 | 1.S mezipatro | K04.102259 | 1.S mezipatro | 78.54 | RPO-N1.11
102280 | 1.NP | K04.102280 | 1.NP | 78.54 | RPO-N1.11
102282 | 1.NP | K04.102282 | 1.NP | 39.27 | RPO-N1.11
102284 | 1.NP | K04.102284 | 1.NP | 39.27 | RPO-N1.11
102309 | 2.NP | K04.102309 | 2.NP | 78.54 | RPO-N2.11
102315 | 2.NP | K04.102315 | 2.NP | 78.54 | RPO-N2.11
102321 | 2.NP | K04.102321 | 2.NP | 78.54 | RPO-N2.11
102327 | 2.NP | K04.102327 | 2.NP | 78.54 | RPO-N2.11
102333 | 2.NP | K04.102333 | 2.NP | 78.54 | RPO-N2.11
102358 | 2.NP | K04.102358 | 2.NP | 78.54 | RPO-N2.11
102360 | 2.NP | K04.102360 | 2.NP | 39.27 | RPO-N2.11
102362 | 2.NP | K04.102362 | 2.NP | 39.27 | RPO-N2.11
102513 | 2.NP | K04.102513 | 2.NP | 78.54 | RPO-N2.11
102516 | 2.NP | K04.102516 | 2.NP | 78.54 | RPO-N2.11
102552 | 1.NP mezipatro | K04.102552 | 1.NP mezipatro | 78.54 | RPO-N2.11
102554 | 2.NP | K04.102554 | 2.NP | 78.54 | RPO-N2.11
103023 | 2.NP mezipatro | K04.103023 | 2.NP mezipatro | 78.54 | RPO-N2.01
103025 | 2.NP mezipatro | K04.103025 | 2.NP mezipatro | 78.54 | RPO-N2.01
103037 | 2.NP mezipatro | K04.103037 | 2.NP mezipatro | 78.54 | RPO-N2.01
103054 | 2.NP mezipatro | K04.103054 | 2.NP mezipatro | 78.54 | RPO-N2.01
103057 | 2.NP mezipatro | K04.103057 | 2.NP mezipatro | 78.54 | RPO-N2.01
103063 | 2.NP mezipatro | K04.103063 | 2.NP mezipatro | 78.54 | RPO-N2.01
103069 | 2.NP mezipatro | K04.103069 | 2.NP mezipatro | 78.54 | RPO-N2.01
103075 | 2.NP mezipatro | K04.103075 | 2.NP mezipatro | 78.54 | RPO-N2.01
103081 | 2.NP mezipatro | K04.103081 | 2.NP mezipatro | 78.54 | RPO-N2.01
103167 | 2.NP mezipatro | K04.103167 | 2.NP mezipatro | 78.54 | RPO-N2.01
103190 | 2.NP mezipatro | K04.103190 | 2.NP mezipatro | 39.27 | RPO-N2.01
103192 | 2.NP mezipatro | K04.103192 | 2.NP mezipatro | 39.27 | RPO-N2.01
103194 | 2.NP mezipatro | K04.103194 | 2.NP mezipatro | 78.54 | RPO-N2.01
103197 | 2.NP mezipatro | K04.103197 | 2.NP mezipatro | 78.54 | RPO-N2.01
103220 | 3.NP mezipatro | K04.103220 | 3.NP mezipatro | 78.54 | RPO-N3.01
103222 | 3.NP mezipatro | K04.103222 | 3.NP mezipatro | 78.54 | RPO-N3.01
103232 | 3.NP mezipatro | K04.103232 | 3.NP mezipatro | 78.54 | RPO-N3.01
103249 | 3.NP mezipatro | K04.103249 | 3.NP mezipatro | 78.54 | RPO-N3.01
103251 | 3.NP mezipatro | K04.103251 | 3.NP mezipatro | 78.54 | RPO-N3.01
103263 | 3.NP mezipatro | K04.103263 | 3.NP mezipatro | 78.54 | RPO-N3.01
103269 | 3.NP mezipatro | K04.103269 | 3.NP mezipatro | 78.54 | RPO-N3.01
103275 | 3.NP mezipatro | K04.103275 | 3.NP mezipatro | 78.54 | RPO-N3.01
103283 | 3.NP mezipatro | K04.103283 | 3.NP mezipatro | 39.27 | RPO-N3.01
103285 | 3.NP mezipatro | K04.103285 | 3.NP mezipatro | 39.27 | RPO-N3.01
103287 | 3.NP mezipatro | K04.103287 | 3.NP mezipatro | 78.54 | RPO-N3.01
103289 | 3.NP mezipatro | K04.103289 | 3.NP mezipatro | 78.54 | RPO-N3.01
103301 | 3.NP mezipatro | K04.103301 | 3.NP mezipatro | 8.6 | RPO-N3.01
103339 | 1.S | K04.103339 | 1.S | 78.54 | RPO-N3.01
103363 | 3.NP mezipatro | K04.103363 | 3.NP mezipatro | 78.54 | RPO-N3.01
104046 | 1.NP | K04.104046 | 1.NP | 8.6 | RPO-N1.11
104048 | 1.NP | K04.104048 | 1.NP | 78.54 | RPO-N1.11
104063 | 2.NP | K04.104063 | 2.NP | 78.54 | RPO-N2.11
104065 | 2.NP | K04.104065 | 2.NP | 8.6 | RPO-N2.11
104078 | 1.S | K04.104078 | 1.S | 78.54 | RPO-N3.11
104131 | 3.NP | K04.104131 | 3.NP | 78.54 | RPO-N3.11
104137 | 3.NP | K04.104137 | 3.NP | 78.54 | RPO-N3.11
104143 | 3.NP | K04.104143 | 3.NP | 78.54 | RPO-N3.11
104149 | 3.NP | K04.104149 | 3.NP | 78.54 | RPO-N3.11
104155 | 3.NP | K04.104155 | 3.NP | 78.54 | RPO-N3.11
104164 | 3.NP | K04.104164 | 3.NP | 78.54 | RPO-N3.11
104166 | 3.NP | K04.104166 | 3.NP | 39.27 | RPO-N3.11
104168 | 3.NP | K04.104168 | 3.NP | 39.27 | RPO-N3.11
104206 | 3.NP | K04.104206 | 3.NP | 78.54 | RPO-N3.11
104208 | 3.NP | K04.104208 | 3.NP | 8.6 | RPO-N3.11
104267 | 3.NP | K04.104267 | 3.NP | 78.54 | RPO-N3.11
104269 | 3.NP | K04.104269 | 3.NP | 78.54 | RPO-N3.11
104272 | 1.NP mezipatro | K04.104272 | 1.NP mezipatro | 78.54 | RPO-N3.11
104274 | 3.NP | K04.104274 | 3.NP | 78.54 | RPO-N3.11
104330 | 3.NP | K04.104330 | 3.NP | 78.54 | RPO-N3.11
106832 | 4.NP | K04.106832 | 4.NP | 78.54 | RPO-N4.11
106841 | 4.NP | K04.106841 | 4.NP | 78.54 | RPO-N4.11
106843 | 4.NP | K04.106843 | 4.NP | 78.54 | RPO-N4.11
106921 | 5.NP | K04.106921 | 5.NP | 39.27 | RPO-N5.11
106953 | 5.NP | K04.106953 | 5.NP | 39.27 | RPO-N5.11
106955 | 5.NP | K04.106955 | 5.NP | 78.54 | RPO-N5.11
106972 | 5.NP | K04.106972 | 5.NP | 78.54 | RPO-N5.11
106987 | 5.NP | K04.106987 | 5.NP | 78.54 | RPO-N5.11
106989 | 5.NP | K04.106989 | 5.NP | 78.54 | RPO-N5.11
117504 | 1.NP mezipatro | K04.117504 | 1.NP mezipatro | 78.54 | RPO-KL-SF 1.1.01
117662 | 4.NP mezipatro | K04.117662 | 4.NP mezipatro | 78.54 | RPO-KL-SF 1.1.01
117665 | 4.NP mezipatro | K04.117665 | 4.NP mezipatro | 78.54 | RPO-KL-SF 1.1.01
123498 | 1.S | K04.123498 | 1.S | 20.47 | RPO-N5.11
123893 | 1.S | K04.123893 | 1.S | 78.54 | RPO-N5.11
123899 | 1.S | K04.123899 | 1.S | 20.47 | RPO-N5.11
124076 | 1.S | K04.124076 | 1.S | 78.54 | RPO-N0.06
124178 | 1.S | K04.124178 | 1.S | 20.47 | RPO-N0.06
132272 | 1.S | K04.132272 | 1.S | 78.54 | RPO-N0.04
132592 | 1.S | K04.132592 | 1.S | 78.54 | RPO-N0.04
132632 | 1.S | K04.132632 | 1.S | 78.54 | RPO-N0.04
132636 | 1.S | K04.132636 | 1.S | 78.54 | RPO-N0.04
132638 | 1.S | K04.132638 | 1.S | 78.54 | RPO-N0.04
133941 | 1.NP mezipatro | K04.133941 | 1.NP mezipatro | 78.54 | RPO-N1.01
134181 | 2.NP mezipatro | K04.134181 | 2.NP mezipatro | 8.6 | RPO-N2.01
134246 | 2.NP mezipatro | K04.134246 | 2.NP mezipatro | 78.54 | RPO-N2.01
134358 | 2.NP | K04.134358 | 2.NP | 78.54 | RPO-N2.11
134415 | 3.NP mezipatro | K04.134415 | 3.NP mezipatro | 8.6 | RPO-N3.01
134548 | 3.NP mezipatro | K04.134548 | 3.NP mezipatro | 78.54 | RPO-N3.01
188848 | 1.S | K04.188848 | 1.S | 78.54 | RPO-N0.01
188850 | 1.S | K04.188850 | 1.S | 78.54 | RPO-N0.01
188852 | 1.S | K04.188852 | 1.S | 78.54 | RPO-N0.01
188854 | 1.S | K04.188854 | 1.S | 78.54 | RPO-N0.01
188874 | 1.S | K04.188874 | 1.S | 78.54 | RPO-N1.11
188878 | 1.S mezipatro | K04.188878 | 1.S mezipatro | 78.54 | RPO-N1.11
188880 | 1.S mezipatro | K04.188880 | 1.S mezipatro | 78.54 | RPO-N1.11
188882 | 1.S | K04.188882 | 1.S | 78.54 | RPO-N1.11
188889 | 1.S mezipatro | K04.188889 | 1.S mezipatro | 78.54 | RPO-N2.11
188891 | 1.S | K04.188891 | 1.S | 78.54 | RPO-N2.11
188893 | 1.S mezipatro | K04.188893 | 1.S mezipatro | 78.54 | RPO-N2.11
188895 | 1.S | K04.188895 | 1.S | 78.54 | RPO-N2.11
188904 | 1.S | K04.188904 | 1.S | 78.54 | RPO-N1.01
188906 | 1.S mezipatro | K04.188906 | 1.S mezipatro | 78.54 | RPO-N1.01
188911 | 1.S | K04.188911 | 1.S | 78.54 | RPO-N0.11
188915 | 1.S | K04.188915 | 1.S | 78.54 | RPO-N0.11
188917 | 1.S mezipatro | K04.188917 | 1.S mezipatro | 78.54 | RPO-N0.11
188938 | 1.S mezipatro | K04.188938 | 1.S mezipatro | 78.54 | RPO-KL-SF 1.1.01
188940 | 1.S mezipatro | K04.188940 | 1.S mezipatro | 78.54 | RPO-KL-SF 1.1.01
188942 | 1.S | K04.188942 | 1.S | 78.54 | RPO-KL-SF 1.1.01
188953 | 1.S | K04.188953 | 1.S | 78.54 | RPO-N3.11
188955 | 1.S mezipatro | K04.188955 | 1.S mezipatro | 78.54 | RPO-N3.11
188965 | 1.S | K04.188965 | 1.S | 78.54 | RPO-N3.01
189026 | 1.S | K04.189026 | 1.S | 78.54 | RPO-N0.05
189032 | 1.S | K04.189032 | 1.S | 78.54 | RPO-N0.05
189034 | 1.S mezipatro | K04.189034 | 1.S mezipatro | 78.54 | RPO-N0.05
189050 | 1.S | K04.189050 | 1.S | 78.54 | RPO-N0.03
189098 | 1.S | K04.189098 | 1.S | 78.54 | RPO-N0.03
189100 | 1.S | K04.189100 | 1.S | 78.54 | RPO-N0.03
189102 | 1.S | K04.189102 | 1.S | 78.54 | RPO-N0.03
189239 | 1.S | K04.189239 | 1.S | 78.54 | RPO-N0.03
189242 | 1.S | K04.189242 | 1.S | 78.54 | RPO-N0.03
189336 | 1.S | K04.189336 | 1.S | 78.54 | RPO-N4.01
189344 | 1.S | K04.189344 | 1.S | 78.54 | RPO-N4.01
189428 | 1.S | K04.189428 | 1.S | 78.54 | RPO-N4.01
189430 | 1.S | K04.189430 | 1.S | 78.54 | RPO-N4.01
189537 | 1.S | K04.189537 | 1.S | 78.54 | RPO-N4.11
189545 | 1.S | K04.189545 | 1.S | 78.54 | RPO-N4.11
189727 | 1.S | K04.189727 | 1.S | 78.54 | RPO-N4.11
189729 | 1.S | K04.189729 | 1.S | 78.54 | RPO-N4.11
189851 | 1.S | K04.189851 | 1.S | 78.54 | RPO-N0.04
189854 | 1.S | K04.189854 | 1.S | 78.54 | RPO-N0.04
189881 | 1.S | K04.189881 | 1.S | 78.54 | RPO-N0.04
189884 | 1.S | K04.189884 | 1.S | 78.54 | RPO-N0.04
189982 | 1.S | K04.189982 | 1.S | 78.54 | RPO-N0.05
189985 | 1.S | K04.189985 | 1.S | 78.54 | RPO-N0.05
190030 | 1.S | K04.190030 | 1.S | 78.54 | RPO-N0.11
190032 | 1.S | K04.190032 | 1.S | 11.65 | RPO-N0.11
190059 | 1.S | K04.190059 | 1.S | 78.54 | RPO-N1.11
190062 | 1.S | K04.190062 | 1.S | 11.65 | RPO-N1.11
190193 | 1.S mezipatro | K04.190193 | 1.S mezipatro | 78.54 | RPO-N3.11
190296 | 1.S | K04.190296 | 1.S | 78.54 | RPO-N5.11
190299 | 1.S | K04.190299 | 1.S | 78.54 | RPO-N5.11
190302 | 1.S | K04.190302 | 1.S | 78.54 | RPO-N5.11
190305 | 1.S | K04.190305 | 1.S | 78.54 | RPO-N5.11
190527 | 1.S | K04.190527 | 1.S | 78.54 | RPO-N0.03
190658 | 1.S | K04.190658 | 1.S | 78.54 | RPO-N0.03
191007 | 1.S | K04.191007 | 1.S | 78.54 | RPO-N0.06
191010 | 1.S | K04.191010 | 1.S | 78.54 | RPO-N0.06
191074 | 1.S | K04.191074 | 1.S | 78.54 | RPO-N0.06
191076 | 1.S | K04.191076 | 1.S | 78.54 | RPO-N0.06
191245 | 1.S | K04.191245 | 1.S | 78.54 | RPO-N1.01
191248 | 1.S | K04.191248 | 1.S | 78.54 | RPO-N1.01
192831 | 1.S mezipatro | K04.192831 | 1.S mezipatro | 78.54 | RPO-N2.01
192835 | 1.S mezipatro | K04.192835 | 1.S mezipatro | 78.54 | RPO-N2.01
192837 | 1.S | K04.192837 | 1.S | 78.54 | RPO-N2.01
192851 | 1.S | K04.192851 | 1.S | 78.54 | RPO-N2.01
192853 | 1.S mezipatro | K04.192853 | 1.S mezipatro | 78.54 | RPO-N2.01
192861 | 1.S mezipatro | K04.192861 | 1.S mezipatro | 78.54 | RPO-N3.01
192867 | 1.S | K04.192867 | 1.S | 78.54 | RPO-N3.01
192869 | 1.S mezipatro | K04.192869 | 1.S mezipatro | 78.54 | RPO-N3.01
192878 | 1.S | K04.192878 | 1.S | 78.54 | RPO-N0.02
192880 | 1.S | K04.192880 | 1.S | 11.65 | RPO-N0.02
192888 | 1.S | K04.192888 | 1.S | 78.54 | RPO-N0.02
192890 | 1.S mezipatro | K04.192890 | 1.S mezipatro | 78.54 | RPO-N0.02
192892 | 1.S | K04.192892 | 1.S | 78.54 | RPO-N0.02
192894 | 1.S mezipatro | K04.192894 | 1.S mezipatro | 78.54 | RPO-N0.02
192939 | 1.S mezipatro | K04.192939 | 1.S mezipatro | 78.54 | RPO-N0.02
192991 | 1.S mezipatro | K04.192991 | 1.S mezipatro | 78.54 | RPO-KL-SF 1.1.01
193926 | 1.S | K04.193926 | 1.S | 78.54 | RPO-N3.11
193928 | 1.NP mezipatro | K04.193928 | 1.NP mezipatro | 78.54 | RPO-N3.11
194016 | 1.S | K04.194016 | 1.S | 78.54 | RPO-N2.11
194018 | 1.NP mezipatro | K04.194018 | 1.NP mezipatro | 78.54 | RPO-N2.11
204026 | 1.S | K04.204026 | 1.S | 78.54 | RPO-N0.04
204452 | 1.S | K04.204452 | 1.S | 78.54 | RPO-KL-SF 1.1.01
204457 | 1.S | K04.204457 | 1.S | 21.82 | RPO-KL-SF 1.1.01
204460 | 1.S | K04.204460 | 1.S | 21.82 | RPO-KL-SF 1.1.01
204664 | 1.S | K04.204664 | 1.S | 11.65 | RPO-N0.02
204669 | 1.S | K04.204669 | 1.S | 21.82 | RPO-N0.02
204672 | 1.S | K04.204672 | 1.S | 21.82 | RPO-N0.02
204752 | 1.S | K04.204752 | 1.S | 78.54 | RPO-N0.02
204755 | 1.S | K04.204755 | 1.S | 78.54 | RPO-N0.02
204846 | 1.S | K04.204846 | 1.S | 21.82 | RPO-N0.06
204849 | 1.S mezipatro | K04.204849 | 1.S mezipatro | 78.54 | RPO-N0.06
204934 | 1.S | K04.204934 | 1.S | 39.27 | RPO-N0.06
204937 | 1.S | K04.204937 | 1.S | 39.27 | RPO-N0.06
204939 | 1.S | K04.204939 | 1.S | 78.54 | RPO-N0.06
207302 | 1.S mezipatro | K04.207302 | 1.S mezipatro | 78.54 | RPO-N0.11
232309 | 5.NP | K04.232309 | 5.NP | 78.54 | RPO-N5.11
232312 | 5.NP | K04.232312 | 5.NP | 78.54 | RPO-N5.11
232323 | 1.S | K04.232323 | 1.S | 78.54 | RPO-N5.11
233306 | 5.NP mezipatro | K04.233306 | 5.NP mezipatro | 78.54 | RPO-KL-SF 1.1.01
233309 | 5.NP mezipatro | K04.233309 | 5.NP mezipatro | 78.54 | RPO-KL-SF 1.1.01
233373 | 5.NP mezipatro | K04.233373 | 5.NP mezipatro | 78.54 | RPO-KL-SF 1.1.01
234628 | 5.NP | K04.234628 | 5.NP | 78.54 | RPO-N5.11
234641 | 5.NP | K04.234641 | 5.NP | 78.54 | RPO-N5.11
234643 | 5.NP mezipatro | K04.234643 | 5.NP mezipatro | 78.54 | RPO-N5.11

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CXKH-V-J 3x2,5 (16)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 3x2,5; ElementProjectSpecificDescription: CXKH-V-J 3x2,5; ElementProjectSpecificIdentifier: K05; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 3x2,5
Pset_DistributionSystemCommon - Reference: RPO
Name (#Elektroinstalační trubka, koleno:CXKH-V-J 3x2,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
116862 | 1.S | K05.116862 | 1.S | 157.08 | Rozvaděče
192438 | 1.S | K05.192438 | 1.S | 78.54 | Rozvaděče
192443 | 1.S | K05.192443 | 1.S | 78.54 | Rozvaděče
192446 | 1.S | K05.192446 | 1.S | 78.54 | Rozvaděče
192481 | 1.S | K05.192481 | 1.S | 78.54 | Rozvaděče
192484 | 1.S | K05.192484 | 1.S | 78.54 | Rozvaděče
192492 | 1.S | K05.192492 | 1.S | 78.54 | Rozvaděče
192494 | 1.S | K05.192494 | 1.S | 157.08 | Rozvaděče
206458 | 1.S | K05.206458 | 1.S | 78.54 | RPO-EPS
206463 | 1.S | K05.206463 | 1.S | 78.54 | RPO-EPS
206466 | 1.S | K05.206466 | 1.S | 78.54 | RPO-EPS
206468 | 1.S mezipatro | K05.206468 | 1.S mezipatro | 78.54 | RPO-EPS
206470 | 1.S | K05.206470 | 1.S | 78.54 | RPO-EPS
206473 | 1.S | K05.206473 | 1.S | 78.54 | RPO-EPS
206475 | 1.S | K05.206475 | 1.S | 78.54 | RPO-EPS
206477 | 1.S | K05.206477 | 1.S | 78.54 | RPO-EPS

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CXKH-V-J 4x10+CYA25ZŽ (3)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 4x10+CYA25ZŽ; ElementProjectSpecificDescription: CXKH-V-J 4x10+CYA25ZŽ; ElementProjectSpecificIdentifier: K06; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 4x10+CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 157.08
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (#Elektroinstalační trubka, koleno:CXKH-V-J 4x10+CYA25ZŽ:...) | Reference
114144 | K06.114144
114161 | K06.114161
114206 | K06.114206

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CXKH-V-J 5x2,5 (18)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-J 5x2,5; ElementProjectSpecificDescription: CXKH-V-J 5x2,5; ElementProjectSpecificIdentifier: K07; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-J 5x2,5
Pset_DistributionSystemCommon - Reference: RPO
Name (#Elektroinstalační trubka, koleno:CXKH-V-J 5x2,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
80676 | Střecha | K07.80676 | Střecha | 78.54 | RPO-SF 1.1.01
80681 | Střecha | K07.80681 | Střecha | 78.54 | RPO-SF 1.1.01
80732 | 1.S | K07.80732 | 1.S | 78.54 | RPO-SF 1.1.01
123581 | 1.S | K07.123581 | 1.S | 20.47 | RPO-SF 1.1.01
123584 | 1.S | K07.123584 | 1.S | 20.47 | RPO-SF 1.1.01
124018 | 1.S | K07.124018 | 1.S | 78.54 | RPO-SF 1.1.01
192979 | 1.S | K07.192979 | 1.S | 78.54 | RPO-SF 1.1.01
192981 | 1.S | K07.192981 | 1.S | 78.54 | RPO-SF 1.1.01
192984 | 1.S | K07.192984 | 1.S | 78.54 | RPO-SF 1.1.01
192986 | 1.S | K07.192986 | 1.S | 78.54 | RPO-SF 1.1.01
206312 | 1.S | K07.206312 | 1.S | 78.54 | RPO-NZS
206325 | 1.S | K07.206325 | 1.S | 78.54 | RPO-NZS
206328 | 1.S | K07.206328 | 1.S | 78.54 | RPO-NZS
206330 | 1.S mezipatro | K07.206330 | 1.S mezipatro | 78.54 | RPO-NZS
206332 | 1.S | K07.206332 | 1.S | 78.54 | RPO-NZS
206408 | 1.S | K07.206408 | 1.S | 78.54 | RPO-NZS
206410 | 1.S | K07.206410 | 1.S | 78.54 | RPO-NZS
206412 | 1.S | K07.206412 | 1.S | 78.54 | RPO-NZS

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CXKH-V-O 3x1,5 (36)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CXKH-V-O 3x1,5; ElementProjectSpecificDescription: CXKH-V-O 3x1,5; ElementProjectSpecificIdentifier: K08; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CXKH-V-O 3x1,5
Pset_DistributionSystemCommon - Reference: RPO
Name (#Elektroinstalační trubka, koleno:CXKH-V-O 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
80786 | 1.S | K08.80786 | 1.S | 78.54 | RPO-Stop FVE
80895 | 1.S | K08.80895 | 1.S | 78.54 | RPO-Stop FVE
80897 | 1.S | K08.80897 | 1.S | 39.27 | RPO-Stop FVE
80899 | 1.S | K08.80899 | 1.S | 39.27 | RPO-Stop FVE
80929 | 1.S | K08.80929 | 1.S | 78.54 | RPO-Stop FVE
81017 | 1.S | K08.81017 | 1.S | 78.54 | RPO-Stop NAB
81022 | 1.S | K08.81022 | 1.S | 78.54 | RPO-Stop NAB
81024 | 1.S | K08.81024 | 1.S | 39.27 | RPO-Stop NAB
81026 | 1.S | K08.81026 | 1.S | 39.27 | RPO-Stop NAB
81030 | 1.S | K08.81030 | 1.S | 78.54 | RPO-Stop NAB
81092 | 1.S | K08.81092 | 1.S | 78.54 | RPO-TS
81099 | 1.S | K08.81099 | 1.S | 39.27 | RPO-TS
81101 | 1.S | K08.81101 | 1.S | 39.27 | RPO-TS
81105 | 1.S | K08.81105 | 1.S | 78.54 | RPO-TS
117791 | 1.S | K08.117791 | 1.S | 78.54 | RPO-CS
117796 | 1.S | K08.117796 | 1.S | 78.54 | RPO-CS
117798 | 1.S | K08.117798 | 1.S | 39.27 | RPO-CS
117800 | 1.S | K08.117800 | 1.S | 39.27 | RPO-CS
117804 | 1.S | K08.117804 | 1.S | 78.54 | RPO-CS
188926 | 1.S | K08.188926 | 1.S | 78.54 | RPO-CS
188928 | 1.S mezipatro | K08.188928 | 1.S mezipatro | 78.54 | RPO-CS
188973 | 1.S | K08.188973 | 1.S | 78.54 | RPO-TS
188977 | 1.S | K08.188977 | 1.S | 78.54 | RPO-TS
188979 | 1.S mezipatro | K08.188979 | 1.S mezipatro | 78.54 | RPO-TS
188994 | 1.S | K08.188994 | 1.S | 78.54 | RPO-Stop NAB
188996 | 1.S mezipatro | K08.188996 | 1.S mezipatro | 78.54 | RPO-Stop NAB
189009 | 1.S | K08.189009 | 1.S | 78.54 | RPO-Stop FVE
189011 | 1.S mezipatro | K08.189011 | 1.S mezipatro | 78.54 | RPO-Stop FVE
192955 | 1.S | K08.192955 | 1.S | 78.54 | RPO-TS
192957 | 1.S | K08.192957 | 1.S | 78.54 | RPO-TS
192961 | 1.S | K08.192961 | 1.S | 78.54 | RPO-Stop NAB
192963 | 1.S mezipatro | K08.192963 | 1.S mezipatro | 78.54 | RPO-Stop NAB
192967 | 1.S | K08.192967 | 1.S | 78.54 | RPO-Stop FVE
192969 | 1.S mezipatro | K08.192969 | 1.S mezipatro | 78.54 | RPO-Stop FVE
193005 | 1.S | K08.193005 | 1.S | 78.54 | RPO-CS
193007 | 1.S mezipatro | K08.193007 | 1.S mezipatro | 78.54 | RPO-CS

# IfcCableCarrierFitting: #Elektroinstalační trubka, koleno:CYKY-J 3x1,5 (1380)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x1,5; ElementProjectSpecificDescription: CYKY-J 3x1,5; ElementProjectSpecificIdentifier: K09; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x1,5
Pset_DistributionSystemCommon - Reference: R-RS
Name (#Elektroinstalační trubka, koleno:CYKY-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
40932 | 1.S | K09.40932 | 1.S | 78.54 | R-RS-LM0.10
40943 | 1.S | K09.40943 | 1.S | 78.54 | R-RS-LM0.10
40951 | 1.S | K09.40951 | 1.S | 78.54 | R-RS-LM0.10
40963 | 1.S | K09.40963 | 1.S | 78.54 | R-RS-LM0.10
41074 | 1.S | K09.41074 | 1.S | 78.54 | R-RS-LM0.10
41110 | 1.S | K09.41110 | 1.S | 78.54 | R-RS-LM0.10
41112 | 1.S | K09.41112 | 1.S | 39.27 | R-RS-LM0.10
41114 | 1.S | K09.41114 | 1.S | 39.27 | R-RS-LM0.10
41834 | 1.S | K09.41834 | 1.S | 78.54 | R-RS-LM0.10
42111 | 1.S | K09.42111 | 1.S | 78.54 | R-RS-LM0.10
42440 | 1.S | K09.42440 | 1.S | 78.54 | R-RS-LM0.10
42702 | 1.S | K09.42702 | 1.S | 78.54 | R-RS-LM0.11
42713 | 1.S | K09.42713 | 1.S | 78.54 | R-RS-LM0.11
42721 | 1.S | K09.42721 | 1.S | 78.54 | R-RS-LM0.11
42943 | 1.S | K09.42943 | 1.S | 78.54 | R-RS-LM0.11
48804 | 4.NP | K09.48804 | 4.NP | 78.54 | R-RS-LM4.13
49213 | 4.NP | K09.49213 | 4.NP | 78.54 | R-RS-LM4.13
49227 | 4.NP | K09.49227 | 4.NP | 78.54 | R-RS-LM4.13
49316 | 4.NP | K09.49316 | 4.NP | 78.54 | R-RS-LM4.13
49527 | 4.NP | K09.49527 | 4.NP | 78.54 | R-RS-LM4.13
49561 | 4.NP | K09.49561 | 4.NP | 78.54 | R-RS-LM4.13
49675 | 4.NP | K09.49675 | 4.NP | 78.54 | R-RS-LM4.13
49678 | 4.NP | K09.49678 | 4.NP | 78.54 | R-RS-LM4.13
50676 | 4.NP | K09.50676 | 4.NP | 78.54 | R-RS-LM4.13
50678 | 4.NP | K09.50678 | 4.NP | 78.54 | R-RS-LM4.13
50719 | 4.NP | K09.50719 | 4.NP | 39.27 | R-RS-LM4.13
50721 | 4.NP | K09.50721 | 4.NP | 39.27 | R-RS-LM4.13
50723 | 4.NP | K09.50723 | 4.NP | 78.54 | R-RS-LM4.13
50781 | 4.NP | K09.50781 | 4.NP | 78.54 | R-RS-LM4.13
50798 | 4.NP | K09.50798 | 4.NP | 78.54 | R-RS-LM4.13
50877 | 4.NP | K09.50877 | 4.NP | 78.54 | R-RS-LM4.13
50879 | 4.NP | K09.50879 | 4.NP | 78.54 | R-RS-LM4.13
50939 | 4.NP | K09.50939 | 4.NP | 78.54 | R-RS-LM4.13
50953 | 4.NP | K09.50953 | 4.NP | 78.54 | R-RS-LM4.13
50955 | 4.NP | K09.50955 | 4.NP | 78.54 | R-RS-LM4.13
51044 | 4.NP | K09.51044 | 4.NP | 78.54 | R-RS-LM4.13
51047 | 4.NP | K09.51047 | 4.NP | 39.27 | R-RS-LM4.13
51049 | 4.NP | K09.51049 | 4.NP | 39.27 | R-RS-LM4.13
51051 | 4.NP | K09.51051 | 4.NP | 78.54 | R-RS-LM4.13
51913 | 1.S | K09.51913 | 1.S | 78.54 | R-RS-LM4.14
51916 | 1.S | K09.51916 | 1.S | 78.54 | R-RS-LM4.14
51919 | 1.S | K09.51919 | 1.S | 78.54 | R-RS-LM4.14
51937 | 1.S | K09.51937 | 1.S | 78.54 | R-RS-LM4.14
52028 | 4.NP | K09.52028 | 4.NP | 78.54 | R-RS-LM4.14
52341 | 4.NP | K09.52341 | 4.NP | 78.54 | R-RS-LM4.14
52464 | 4.NP | K09.52464 | 4.NP | 78.54 | R-RS-LM4.14
52479 | 4.NP | K09.52479 | 4.NP | 78.54 | R-RS-LM4.14
52489 | 4.NP | K09.52489 | 4.NP | 78.54 | R-RS-LM4.14
52499 | 4.NP | K09.52499 | 4.NP | 78.54 | R-RS-LM4.14
52518 | 4.NP | K09.52518 | 4.NP | 78.54 | R-RS-LM4.14
52528 | 4.NP | K09.52528 | 4.NP | 78.54 | R-RS-LM4.14
52643 | 4.NP | K09.52643 | 4.NP | 78.54 | R-RS-LM4.14
52653 | 4.NP | K09.52653 | 4.NP | 78.54 | R-RS-LM4.14
52661 | 4.NP | K09.52661 | 4.NP | 78.54 | R-RS-LM4.14
52703 | 4.NP | K09.52703 | 4.NP | 78.54 | R-RS-LM4.14
52713 | 4.NP | K09.52713 | 4.NP | 78.54 | R-RS-LM4.14
52721 | 4.NP | K09.52721 | 4.NP | 78.54 | R-RS-LM4.14
52731 | 4.NP | K09.52731 | 4.NP | 78.54 | R-RS-LM4.14
52739 | 4.NP | K09.52739 | 4.NP | 78.54 | R-RS-LM4.14
53009 | 1.S | K09.53009 | 1.S | 78.54 | R-RS-LM4.04
53012 | 1.S | K09.53012 | 1.S | 78.54 | R-RS-LM4.04
53015 | 1.S | K09.53015 | 1.S | 78.54 | R-RS-LM4.04
53033 | 1.S | K09.53033 | 1.S | 78.54 | R-RS-LM4.04
54122 | 4.NP | K09.54122 | 4.NP | 8.25 | R-RS-LM4.14
54124 | 4.NP | K09.54124 | 4.NP | 78.54 | R-RS-LM4.14
54386 | 4.NP | K09.54386 | 4.NP | 78.54 | R-RS-LM4.14
54664 | 4.NP | K09.54664 | 4.NP | 78.54 | R-RS-LM4.14
54669 | 4.NP | K09.54669 | 4.NP | 78.54 | R-RS-LM4.14
54672 | 4.NP | K09.54672 | 4.NP | 78.54 | R-RS-LM4.14
54702 | 4.NP mezipatro | K09.54702 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54727 | 4.NP mezipatro | K09.54727 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54746 | 4.NP mezipatro | K09.54746 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54750 | 4.NP mezipatro | K09.54750 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54766 | 4.NP mezipatro | K09.54766 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54770 | 4.NP mezipatro | K09.54770 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54780 | 4.NP mezipatro | K09.54780 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54785 | 4.NP mezipatro | K09.54785 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
54789 | 4.NP mezipatro | K09.54789 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
56089 | 4.NP mezipatro | K09.56089 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
56091 | 4.NP mezipatro | K09.56091 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
56122 | 4.NP mezipatro | K09.56122 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
56192 | 1.S | K09.56192 | 1.S | 78.54 | R-RS-LM4.13
56195 | 1.S | K09.56195 | 1.S | 78.54 | R-RS-LM4.13
56198 | 1.S | K09.56198 | 1.S | 78.54 | R-RS-LM4.13
56213 | 1.S | K09.56213 | 1.S | 78.54 | R-RS-LM4.13
56547 | 1.S | K09.56547 | 1.S | 78.54 | R-RS-LM2.04
56550 | 1.S | K09.56550 | 1.S | 78.54 | R-RS-LM2.04
56553 | 1.S | K09.56553 | 1.S | 78.54 | R-RS-LM2.04
56556 | 1.S | K09.56556 | 1.S | 78.54 | R-RS-LM2.04
56568 | 1.S | K09.56568 | 1.S | 78.54 | R-RS-LM2.04
56605 | 2.NP mezipatro | K09.56605 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56613 | 2.NP mezipatro | K09.56613 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56644 | 2.NP mezipatro | K09.56644 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56683 | 2.NP mezipatro | K09.56683 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56686 | 2.NP mezipatro | K09.56686 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56689 | 2.NP mezipatro | K09.56689 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56695 | 2.NP mezipatro | K09.56695 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56698 | 2.NP mezipatro | K09.56698 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56701 | 2.NP mezipatro | K09.56701 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
56704 | 2.NP mezipatro | K09.56704 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
57338 | 1.S | K09.57338 | 1.S | 78.54 | R-RS-LM0.12
57341 | 1.S | K09.57341 | 1.S | 78.54 | R-RS-LM0.12
57344 | 1.S | K09.57344 | 1.S | 78.54 | R-RS-LM0.12
57359 | 1.S | K09.57359 | 1.S | 78.54 | R-RS-LM0.12
57396 | 1.S mezipatro | K09.57396 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57404 | 1.S mezipatro | K09.57404 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57409 | 1.S mezipatro | K09.57409 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57411 | 1.S mezipatro | K09.57411 | 1.S mezipatro | 39.27 | R-RS-LM0.12
57477 | 1.S mezipatro | K09.57477 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57480 | 1.S mezipatro | K09.57480 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57486 | 1.S mezipatro | K09.57486 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57489 | 1.S mezipatro | K09.57489 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57492 | 1.S mezipatro | K09.57492 | 1.S mezipatro | 78.54 | R-RS-LM0.12
57710 | 4.NP mezipatro | K09.57710 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57722 | 4.NP mezipatro | K09.57722 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57729 | 4.NP mezipatro | K09.57729 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57750 | 4.NP mezipatro | K09.57750 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57752 | 4.NP mezipatro | K09.57752 | 4.NP mezipatro | 39.27 | R-RS-LM4.03
57754 | 4.NP mezipatro | K09.57754 | 4.NP mezipatro | 39.27 | R-RS-LM4.03
57756 | 4.NP mezipatro | K09.57756 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57784 | 4.NP mezipatro | K09.57784 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57798 | 4.NP mezipatro | K09.57798 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57801 | 4.NP mezipatro | K09.57801 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57910 | 4.NP mezipatro | K09.57910 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57929 | 4.NP mezipatro | K09.57929 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57946 | 4.NP mezipatro | K09.57946 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
57949 | 4.NP mezipatro | K09.57949 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
59701 | 2.NP | K09.59701 | 2.NP | 78.54 | R-RS-LM2.13
59724 | 2.NP | K09.59724 | 2.NP | 78.54 | R-RS-LM2.13
59726 | 2.NP | K09.59726 | 2.NP | 78.54 | R-RS-LM2.13
59732 | 2.NP | K09.59732 | 2.NP | 78.54 | R-RS-LM2.13
59749 | 2.NP | K09.59749 | 2.NP | 78.54 | R-RS-LM2.13
59751 | 2.NP | K09.59751 | 2.NP | 78.54 | R-RS-LM2.13
59797 | 2.NP | K09.59797 | 2.NP | 78.54 | R-RS-LM2.13
59799 | 2.NP | K09.59799 | 2.NP | 78.54 | R-RS-LM2.13
59804 | 2.NP | K09.59804 | 2.NP | 39.27 | R-RS-LM2.13
59806 | 2.NP | K09.59806 | 2.NP | 39.27 | R-RS-LM2.13
59808 | 2.NP | K09.59808 | 2.NP | 78.54 | R-RS-LM2.13
59810 | 2.NP | K09.59810 | 2.NP | 78.54 | R-RS-LM2.13
59816 | 2.NP | K09.59816 | 2.NP | 78.54 | R-RS-LM2.13
59819 | 2.NP | K09.59819 | 2.NP | 78.54 | R-RS-LM2.13
59825 | 2.NP | K09.59825 | 2.NP | 78.54 | R-RS-LM2.13
59827 | 2.NP | K09.59827 | 2.NP | 78.54 | R-RS-LM2.13
59838 | 2.NP | K09.59838 | 2.NP | 78.54 | R-RS-LM2.13
59840 | 2.NP | K09.59840 | 2.NP | 39.27 | R-RS-LM2.13
59842 | 2.NP | K09.59842 | 2.NP | 39.27 | R-RS-LM2.13
59844 | 2.NP | K09.59844 | 2.NP | 78.54 | R-RS-LM2.13
59851 | 2.NP | K09.59851 | 2.NP | 78.54 | R-RS-LM2.13
60082 | 2.NP | K09.60082 | 2.NP | 78.54 | R-RS-LM2.13
60084 | 2.NP | K09.60084 | 2.NP | 78.54 | R-RS-LM2.13
60153 | 2.NP | K09.60153 | 2.NP | 78.54 | R-RS-LM2.13
60155 | 2.NP | K09.60155 | 2.NP | 78.54 | R-RS-LM2.13
60244 | 4.NP mezipatro | K09.60244 | 4.NP mezipatro | 78.54 | R-RS-LM4.03
62410 | 1.S | K09.62410 | 1.S | 78.54 | R-RS-LM4.03
62413 | 1.S | K09.62413 | 1.S | 78.54 | R-RS-LM4.03
62416 | 1.S | K09.62416 | 1.S | 78.54 | R-RS-LM4.03
62427 | 1.S | K09.62427 | 1.S | 78.54 | R-RS-LM4.03
65669 | 2.NP mezipatro | K09.65669 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65729 | 2.NP mezipatro | K09.65729 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65731 | 2.NP mezipatro | K09.65731 | 2.NP mezipatro | 39.27 | R-RS-LM2.04
65733 | 2.NP mezipatro | K09.65733 | 2.NP mezipatro | 39.27 | R-RS-LM2.04
65735 | 2.NP mezipatro | K09.65735 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65867 | 2.NP mezipatro | K09.65867 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65870 | 2.NP mezipatro | K09.65870 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65883 | 2.NP mezipatro | K09.65883 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65885 | 2.NP mezipatro | K09.65885 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65974 | 2.NP mezipatro | K09.65974 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
65984 | 2.NP mezipatro | K09.65984 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
66112 | 2.NP mezipatro | K09.66112 | 2.NP mezipatro | 39.27 | R-RS-LM2.04
66114 | 2.NP mezipatro | K09.66114 | 2.NP mezipatro | 39.27 | R-RS-LM2.04
66129 | 2.NP mezipatro | K09.66129 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
66132 | 2.NP mezipatro | K09.66132 | 2.NP mezipatro | 78.54 | R-RS-LM2.04
66719 | 4.NP | K09.66719 | 4.NP | 78.54 | R-RS-LM4.13
67238 | 1.S | K09.67238 | 1.S | 78.54 | R-RS-LM4.13
67240 | 1.S | K09.67240 | 1.S | 78.54 | R-RS-LM4.13
67276 | 4.NP | K09.67276 | 4.NP | 78.54 | R-RS-LM4.13
67367 | 1.S | K09.67367 | 1.S | 78.54 | R-RS-LM0.10
67529 | 1.S | K09.67529 | 1.S | 78.54 | R-RS-LM0.10
67545 | 1.S | K09.67545 | 1.S | 78.54 | R-RS-LM0.10
67547 | 1.S | K09.67547 | 1.S | 39.27 | R-RS-LM0.10
67549 | 1.S | K09.67549 | 1.S | 39.27 | R-RS-LM0.10
67629 | 1.S | K09.67629 | 1.S | 78.54 | R-RS-LM0.10
67640 | 1.S | K09.67640 | 1.S | 78.54 | R-RS-LM0.10
67662 | 1.S | K09.67662 | 1.S | 78.54 | R-RS-LM0.10
67665 | 1.S | K09.67665 | 1.S | 78.54 | R-RS-LM0.10
67683 | 1.S | K09.67683 | 1.S | 78.54 | R-RS-LM0.10
68508 | 1.S | K09.68508 | 1.S | 78.54 | R-RS-LM0.10
68856 | 1.S | K09.68856 | 1.S | 19.63 | R-RS-LM0.10
68859 | 1.S | K09.68859 | 1.S | 19.63 | R-RS-LM0.10
68861 | 1.S | K09.68861 | 1.S | 78.54 | R-RS-LM0.10
68930 | 1.S | K09.68930 | 1.S | 78.54 | R-RS-LM0.10
68940 | 1.S | K09.68940 | 1.S | 78.54 | R-RS-LM0.10
68943 | 1.S | K09.68943 | 1.S | 78.54 | R-RS-LM0.10
69939 | 1.S | K09.69939 | 1.S | 78.54 | R-RS-LM0.10
69945 | 1.S | K09.69945 | 1.S | 78.54 | R-RS-LM0.11
69947 | 1.S | K09.69947 | 1.S | 78.54 | R-RS-LM0.11
69958 | 1.S | K09.69958 | 1.S | 78.54 | R-RS-LM0.11
69962 | 1.S | K09.69962 | 1.S | 78.54 | R-RS-LM0.11
69971 | 1.S | K09.69971 | 1.S | 78.54 | R-RS-LM0.11
69975 | 1.S | K09.69975 | 1.S | 78.54 | R-RS-LM0.11
69979 | 1.S | K09.69979 | 1.S | 78.54 | R-RS-LM0.11
69987 | 1.S | K09.69987 | 1.S | 78.54 | R-RS-LM0.11
69990 | 1.S | K09.69990 | 1.S | 78.54 | R-RS-LM0.11
69992 | 1.S | K09.69992 | 1.S | 78.54 | R-RS-LM0.11
70003 | 1.S | K09.70003 | 1.S | 78.54 | R-RS-LM0.11
70007 | 1.S | K09.70007 | 1.S | 78.54 | R-RS-LM0.11
70011 | 1.S | K09.70011 | 1.S | 78.54 | R-RS-LM0.11
70015 | 1.S | K09.70015 | 1.S | 78.54 | R-RS-LM0.11
70019 | 1.S | K09.70019 | 1.S | 78.54 | R-RS-LM0.11
70023 | 1.S | K09.70023 | 1.S | 78.54 | R-RS-LM0.11
70035 | 1.S | K09.70035 | 1.S | 78.54 | R-RS-LM0.11
70037 | 1.S | K09.70037 | 1.S | 78.54 | R-RS-LM0.11
70042 | 1.S | K09.70042 | 1.S | 78.54 | R-RS-LM0.11
70052 | 1.S | K09.70052 | 1.S | 78.54 | R-RS-LM0.11
70054 | 1.S | K09.70054 | 1.S | 78.54 | R-RS-LM0.11
70069 | 1.S | K09.70069 | 1.S | 78.54 | R-RS-LM0.11
70080 | 1.S | K09.70080 | 1.S | 78.54 | R-RS-LM0.11
70085 | 1.S | K09.70085 | 1.S | 78.54 | R-RS-LM0.11
70089 | 1.S | K09.70089 | 1.S | 78.54 | R-RS-LM0.11
70093 | 1.S | K09.70093 | 1.S | 78.54 | R-RS-LM0.11
70099 | 1.S | K09.70099 | 1.S | 78.54 | R-RS-LM0.11
70101 | 1.S | K09.70101 | 1.S | 39.27 | R-RS-LM0.11
70103 | 1.S | K09.70103 | 1.S | 39.27 | R-RS-LM0.11
70150 | 1.S | K09.70150 | 1.S | 78.54 | R-RS-LM0.11
70152 | 1.S | K09.70152 | 1.S | 39.27 | R-RS-LM0.11
70154 | 1.S | K09.70154 | 1.S | 39.27 | R-RS-LM0.11
70172 | 1.S | K09.70172 | 1.S | 78.54 | R-RS-LM0.11
70182 | 1.S | K09.70182 | 1.S | 78.54 | R-RS-LM0.11
70190 | 1.S | K09.70190 | 1.S | 78.54 | R-RS-LM0.11
70734 | 1.S mezipatro | K09.70734 | 1.S mezipatro | 78.54 | R-RS-LM0.12
70760 | 1.S mezipatro | K09.70760 | 1.S mezipatro | 78.54 | R-RS-LM0.12
70915 | 1.S mezipatro | K09.70915 | 1.S mezipatro | 39.27 | R-RS-LM0.12
70917 | 1.S mezipatro | K09.70917 | 1.S mezipatro | 39.27 | R-RS-LM0.12
71034 | 1.S mezipatro | K09.71034 | 1.S mezipatro | 78.54 | R-RS-LM0.12
71147 | 1.S mezipatro | K09.71147 | 1.S mezipatro | 78.54 | R-RS-LM0.12
71185 | 1.S mezipatro | K09.71185 | 1.S mezipatro | 78.54 | R-RS-LM0.12
71217 | 4.NP mezipatro | K09.71217 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71222 | 4.NP mezipatro | K09.71222 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71233 | 4.NP mezipatro | K09.71233 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71236 | 4.NP mezipatro | K09.71236 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71244 | 4.NP mezipatro | K09.71244 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71262 | 4.NP mezipatro | K09.71262 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71264 | 4.NP mezipatro | K09.71264 | 4.NP mezipatro | 39.27 | R-RS-LM4.04
71281 | 4.NP mezipatro | K09.71281 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71285 | 4.NP mezipatro | K09.71285 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71293 | 4.NP mezipatro | K09.71293 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71296 | 4.NP mezipatro | K09.71296 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71308 | 4.NP mezipatro | K09.71308 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71316 | 4.NP mezipatro | K09.71316 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71318 | 4.NP mezipatro | K09.71318 | 4.NP mezipatro | 78.54 | R-RS-LM4.04
71406 | 1.S | K09.71406 | 1.S | 78.54 | R-RS-LM1.05
71409 | 1.S | K09.71409 | 1.S | 78.54 | R-RS-LM1.05
71412 | 1.S | K09.71412 | 1.S | 78.54 | R-RS-LM1.05
71416 | 1.S | K09.71416 | 1.S | 78.54 | R-RS-LM1.05
71426 | 1.NP mezipatro | K09.71426 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71434 | 1.NP mezipatro | K09.71434 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71439 | 1.NP mezipatro | K09.71439 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71441 | 1.NP mezipatro | K09.71441 | 1.NP mezipatro | 39.27 | R-RS-LM1.05
71451 | 1.NP mezipatro | K09.71451 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71454 | 1.NP mezipatro | K09.71454 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71457 | 1.NP mezipatro | K09.71457 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71475 | 1.NP mezipatro | K09.71475 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71478 | 1.NP mezipatro | K09.71478 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71484 | 1.NP mezipatro | K09.71484 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71490 | 1.NP mezipatro | K09.71490 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71513 | 1.NP mezipatro | K09.71513 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71518 | 1.NP mezipatro | K09.71518 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71520 | 1.NP mezipatro | K09.71520 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71536 | 1.NP mezipatro | K09.71536 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71540 | 1.NP mezipatro | K09.71540 | 1.NP mezipatro | 78.54 | R-RS-LM1.05
71542 | 1.NP mezipatro | K09.71542 | 1.NP mezipatro | 39.27 | R-RS-LM1.05
71544 | 1.NP mezipatro | K09.71544 | 1.NP mezipatro | 39.27 | R-RS-LM1.05
