Properties of the parts of a building model (IFC4), part 5 of 7

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x1,5 (1792)
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
59714 | 2.NP | K09.59714 | 2.NP | 4697.07 | R-RS-LM2.13
59715 | 2.NP | K09.59715 | 2.NP | 12167.3 | R-RS-LM2.13
59716 | 2.NP | K09.59716 | 2.NP | 7440 | R-RS-LM2.13
59720 | 2.NP | K09.59720 | 2.NP | 4937.37 | R-RS-LM2.13
59721 | 2.NP | K09.59721 | 2.NP | 94.14 | R-RS-LM2.13
59722 | 2.NP | K09.59722 | 2.NP | 97.82 | R-RS-LM2.13
59723 | 2.NP | K09.59723 | 2.NP | 4799.52 | R-RS-LM2.13
59728 | 2.NP | K09.59728 | 2.NP | 4785.47 | R-RS-LM2.13
59730 | 2.NP | K09.59730 | 2.NP | 1447.01 | R-RS-LM2.13
59731 | 2.NP | K09.59731 | 2.NP | 3778.53 | R-RS-LM2.13
59742 | 2.NP | K09.59742 | 2.NP | 5501.74 | R-RS-LM2.13
59745 | 2.NP | K09.59745 | 2.NP | 2632.84 | R-RS-LM2.13
59746 | 2.NP | K09.59746 | 2.NP | 3661.42 | R-RS-LM2.13
59747 | 2.NP | K09.59747 | 2.NP | 140.3 | R-RS-LM2.13
59748 | 2.NP | K09.59748 | 2.NP | 7650 | R-RS-LM2.13
59755 | 2.NP | K09.59755 | 2.NP | 3963.77 | R-RS-LM2.13
59789 | 2.NP | K09.59789 | 2.NP | 120 | R-RS-LM2.13
59795 | 2.NP | K09.59795 | 2.NP | 120 | R-RS-LM2.13
59802 | 2.NP | K09.59802 | 2.NP | 260.64 | R-RS-LM2.13
59803 | 2.NP | K09.59803 | 2.NP | 241.42 | R-RS-LM2.13
59812 | 2.NP | K09.59812 | 2.NP | 120 | R-RS-LM2.13
59814 | 2.NP | K09.59814 | 2.NP | 2678.01 | R-RS-LM2.13
59821 | 2.NP | K09.59821 | 2.NP | 120 | R-RS-LM2.13
59823 | 2.NP | K09.59823 | 2.NP | 9341.52 | R-RS-LM2.13
59829 | 2.NP | K09.59829 | 2.NP | 120 | R-RS-LM2.13
59831 | 2.NP | K09.59831 | 2.NP | 7928.32 | R-RS-LM2.13
59836 | 2.NP | K09.59836 | 2.NP | 292.56 | R-RS-LM2.13
59837 | 2.NP | K09.59837 | 2.NP | 241.42 | R-RS-LM2.13
60078 | 2.NP | K09.60078 | 2.NP | 3798.29 | R-RS-LM2.13
60079 | 2.NP | K09.60079 | 2.NP | 28.83 | R-RS-LM2.13
60080 | 2.NP | K09.60080 | 2.NP | 17.19 | R-RS-LM2.13
60081 | 2.NP | K09.60081 | 2.NP | 5150 | R-RS-LM2.13
60147 | 2.NP | K09.60147 | 2.NP | 120 | R-RS-LM2.13
60150 | 2.NP | K09.60150 | 2.NP | 7076.83 | R-RS-LM2.13
60236 | 4.NP mezipatro | K09.60236 | 4.NP mezipatro | 720 | R-RS-LM4.03
60248 | 4.NP mezipatro | K09.60248 | 4.NP mezipatro | 4009.99 | R-RS-LM4.03
62408 | 1.S | K09.62408 | 1.S | 121.39 | R-RS-LM4.03
62409 | 1.S | K09.62409 | 1.S | 1394.05 | R-RS-LM4.03
62412 | 1.S | K09.62412 | 1.S | 2353.79 | R-RS-LM4.03
62415 | 1.S | K09.62415 | 1.S | 6764.05 | R-RS-LM4.03
62418 | 1.S | K09.62418 | 1.S | 16051.5 | R-RS-LM4.03
62422 | 4.NP mezipatro | K09.62422 | 4.NP mezipatro | 13400 | R-RS-LM4.03
62426 | 1.S | K09.62426 | 1.S | 950 | R-RS-LM4.03
62429 | 4.NP mezipatro | K09.62429 | 4.NP mezipatro | 2334.71 | R-RS-LM4.03
65538 | 2.NP mezipatro | K09.65538 | 2.NP mezipatro | 6276.81 | R-RS-LM2.04
65725 | 2.NP mezipatro | K09.65725 | 2.NP mezipatro | 123.911 | R-RS-LM2.04
65726 | 2.NP mezipatro | K09.65726 | 2.NP mezipatro | 241.42 | R-RS-LM2.04
65803 | 2.NP mezipatro | K09.65803 | 2.NP mezipatro | 1092.51 | R-RS-LM2.04
65828 | 2.NP mezipatro | K09.65828 | 2.NP mezipatro | 12380.3 | R-RS-LM2.04
65876 | 2.NP mezipatro | K09.65876 | 2.NP mezipatro | 120 | R-RS-LM2.04
65879 | 2.NP mezipatro | K09.65879 | 2.NP mezipatro | 1665.14 | R-RS-LM2.04
65964 | 2.NP mezipatro | K09.65964 | 2.NP mezipatro | 5610.54 | R-RS-LM2.04
66003 | 2.NP mezipatro | K09.66003 | 2.NP mezipatro | 2398.59 | R-RS-LM2.04
66086 | 2.NP mezipatro | K09.66086 | 2.NP mezipatro | 1539.04 | R-RS-LM2.04
66105 | 2.NP mezipatro | K09.66105 | 2.NP mezipatro | 2507.56 | R-RS-LM2.04
66106 | 2.NP mezipatro | K09.66106 | 2.NP mezipatro | 241.42 | R-RS-LM2.04
66120 | 2.NP mezipatro | K09.66120 | 2.NP mezipatro | 120 | R-RS-LM2.04
66123 | 2.NP mezipatro | K09.66123 | 2.NP mezipatro | 2650.64 | R-RS-LM2.04
66270 | 2.NP mezipatro | K09.66270 | 2.NP mezipatro | 9816.84 | R-RS-LM2.04
66559 | 2.NP mezipatro | K09.66559 | 2.NP mezipatro | 7440 | R-RS-LM2.04
66716 | 4.NP | K09.66716 | 4.NP | 6232.27 | R-RS-LM4.13
67370 | 1.S | K09.67370 | 1.S | 6704.83 | R-RS-LM0.10
67384 | 1.S | K09.67384 | 1.S | 4186.12 | R-RS-LM0.10
67480 | 1.S | K09.67480 | 1.S | 399.905 | R-RS-LM0.10
67511 | 1.S | K09.67511 | 1.S | 128.29 | R-RS-LM0.10
67541 | 1.S | K09.67541 | 1.S | 2217.56 | R-RS-LM0.10
67542 | 1.S | K09.67542 | 1.S | 354.56 | R-RS-LM0.10
67621 | 1.S | K09.67621 | 1.S | 1120 | R-RS-LM0.10
67632 | 1.S | K09.67632 | 1.S | 46.18 | R-RS-LM0.10
67642 | 1.S | K09.67642 | 1.S | 396.25 | R-RS-LM0.10
67653 | 1.S | K09.67653 | 1.S | 200 | R-RS-LM0.10
67656 | 1.S | K09.67656 | 1.S | 4073.68 | R-RS-LM0.10
67675 | 1.S | K09.67675 | 1.S | 1030 | R-RS-LM0.10
67896 | 1.S | K09.67896 | 1.S | 5459.5 | R-RS-LM0.10
67906 | 1.S | K09.67906 | 1.S | 3950 | R-RS-LM0.10
68077 | 1.S | K09.68077 | 1.S | 1190.26 | R-RS-LM0.10
68573 | 1.S | K09.68573 | 1.S | 1422.61 | R-RS-LM0.10
68649 | 1.S | K09.68649 | 1.S | 405.986 | R-RS-LM0.10
68671 | 1.S | K09.68671 | 1.S | 1551.81 | R-RS-LM0.10
68716 | 1.S | K09.68716 | 1.S | 4466.43 | R-RS-LM0.10
68726 | 1.S | K09.68726 | 1.S | 99.021 | R-RS-LM0.10
68846 | 1.S | K09.68846 | 1.S | 19.62 | R-RS-LM0.10
68847 | 1.S | K09.68847 | 1.S | 70.073 | R-RS-LM0.10
68851 | 1.S | K09.68851 | 1.S | 4293.72 | R-RS-LM0.10
68870 | 1.S | K09.68870 | 1.S | 160.81 | R-RS-LM0.10
69937 | 1.S | K09.69937 | 1.S | 270 | R-RS-LM0.10
69941 | 1.S | K09.69941 | 1.S | 64.47 | R-RS-LM0.11
69943 | 1.S | K09.69943 | 1.S | 114.41 | R-RS-LM0.11
69949 | 1.S | K09.69949 | 1.S | 799.74 | R-RS-LM0.11
69952 | 1.S | K09.69952 | 1.S | 200 | R-RS-LM0.11
69955 | 1.S | K09.69955 | 1.S | 5340 | R-RS-LM0.11
69960 | 1.S | K09.69960 | 1.S | 2430 | R-RS-LM0.11
69964 | 1.S | K09.69964 | 1.S | 800 | R-RS-LM0.11
69966 | 1.S | K09.69966 | 1.S | 2800 | R-RS-LM0.11
69969 | 1.S | K09.69969 | 1.S | 104.11 | R-RS-LM0.11
69973 | 1.S | K09.69973 | 1.S | 5820 | R-RS-LM0.11
69977 | 1.S | K09.69977 | 1.S | 154.11 | R-RS-LM0.11
69981 | 1.S | K09.69981 | 1.S | 200 | R-RS-LM0.11
69984 | 1.S | K09.69984 | 1.S | 24251.8 | R-RS-LM0.11
69994 | 1.S | K09.69994 | 1.S | 5399.19 | R-RS-LM0.11
69997 | 1.S | K09.69997 | 1.S | 200 | R-RS-LM0.11
70000 | 1.S | K09.70000 | 1.S | 1615.99 | R-RS-LM0.11
70005 | 1.S | K09.70005 | 1.S | 3880 | R-RS-LM0.11
70009 | 1.S | K09.70009 | 1.S | 91.85 | R-RS-LM0.11
70013 | 1.S | K09.70013 | 1.S | 7677.2 | R-RS-LM0.11
70017 | 1.S | K09.70017 | 1.S | 844.82 | R-RS-LM0.11
70021 | 1.S | K09.70021 | 1.S | 5950 | R-RS-LM0.11
70025 | 1.S | K09.70025 | 1.S | 4340 | R-RS-LM0.11
70027 | 1.S | K09.70027 | 1.S | 68.17 | R-RS-LM0.11
70029 | 1.S | K09.70029 | 1.S | 200 | R-RS-LM0.11
70032 | 1.S | K09.70032 | 1.S | 2939.9 | R-RS-LM0.11
70040 | 1.S | K09.70040 | 1.S | 2889.87 | R-RS-LM0.11
70044 | 1.S | K09.70044 | 1.S | 179.14 | R-RS-LM0.11
70046 | 1.S | K09.70046 | 1.S | 200 | R-RS-LM0.11
70049 | 1.S | K09.70049 | 1.S | 3153.16 | R-RS-LM0.11
70061 | 1.S | K09.70061 | 1.S | 6104.83 | R-RS-LM0.11
70063 | 1.S | K09.70063 | 1.S | 200 | R-RS-LM0.11
70066 | 1.S | K09.70066 | 1.S | 50.28 | R-RS-LM0.11
70071 | 1.S | K09.70071 | 1.S | 4155 | R-RS-LM0.11
70074 | 1.S | K09.70074 | 1.S | 200 | R-RS-LM0.11
70077 | 1.S | K09.70077 | 1.S | 16914.8 | R-RS-LM0.11
70083 | 1.S | K09.70083 | 1.S | 3015.89 | R-RS-LM0.11
70087 | 1.S | K09.70087 | 1.S | 1880.78 | R-RS-LM0.11
70091 | 1.S | K09.70091 | 1.S | 5150 | R-RS-LM0.11
70095 | 1.S | K09.70095 | 1.S | 140.72 | R-RS-LM0.11
70096 | 1.S | K09.70096 | 1.S | 354.56 | R-RS-LM0.11
70108 | 1.S | K09.70108 | 1.S | 3803.76 | R-RS-LM0.11
70146 | 1.S | K09.70146 | 1.S | 380.078 | R-RS-LM0.11
70147 | 1.S | K09.70147 | 1.S | 354.56 | R-RS-LM0.11
70164 | 1.S | K09.70164 | 1.S | 83.078 | R-RS-LM0.11
70174 | 1.S | K09.70174 | 1.S | 1900 | R-RS-LM0.11
70184 | 1.S | K09.70184 | 1.S | 75.12 | R-RS-LM0.11
70210 | 1.S | K09.70210 | 1.S | 8950 | R-RS-LM0.11
70580 | 1.S mezipatro | K09.70580 | 1.S mezipatro | 1480 | R-RS-LM0.12
70668 | 1.S mezipatro | K09.70668 | 1.S mezipatro | 5186.9 | R-RS-LM0.12
70726 | 1.S mezipatro | K09.70726 | 1.S mezipatro | 120 | R-RS-LM0.12
70729 | 1.S mezipatro | K09.70729 | 1.S mezipatro | 1716.36 | R-RS-LM0.12
70746 | 1.S mezipatro | K09.70746 | 1.S mezipatro | 2123.55 | R-RS-LM0.12
70754 | 1.S mezipatro | K09.70754 | 1.S mezipatro | 1447.33 | R-RS-LM0.12
70793 | 1.S mezipatro | K09.70793 | 1.S mezipatro | 4474.04 | R-RS-LM0.12
70805 | 1.S mezipatro | K09.70805 | 1.S mezipatro | 120 | R-RS-LM0.12
70808 | 1.S mezipatro | K09.70808 | 1.S mezipatro | 10190.6 | R-RS-LM0.12
70855 | 1.S mezipatro | K09.70855 | 1.S mezipatro | 1695.03 | R-RS-LM0.12
70909 | 1.S mezipatro | K09.70909 | 1.S mezipatro | 1980.6 | R-RS-LM0.12
70910 | 1.S mezipatro | K09.70910 | 1.S mezipatro | 241.42 | R-RS-LM0.12
70985 | 1.S mezipatro | K09.70985 | 1.S mezipatro | 1370.25 | R-RS-LM0.12
71021 | 1.S mezipatro | K09.71021 | 1.S mezipatro | 120 | R-RS-LM0.12
71024 | 1.S mezipatro | K09.71024 | 1.S mezipatro | 1913.1 | R-RS-LM0.12
71082 | 1.S mezipatro | K09.71082 | 1.S mezipatro | 9100 | R-RS-LM0.12
71126 | 1.S mezipatro | K09.71126 | 1.S mezipatro | 982.089 | R-RS-LM0.12
71139 | 1.S mezipatro | K09.71139 | 1.S mezipatro | 11553 | R-RS-LM0.12
71212 | 4.NP mezipatro | K09.71212 | 4.NP mezipatro | 7659.57 | R-RS-LM4.04
71215 | 4.NP mezipatro | K09.71215 | 4.NP mezipatro | 13258 | R-RS-LM4.04
71220 | 4.NP mezipatro | K09.71220 | 4.NP mezipatro | 720 | R-RS-LM4.04
71224 | 4.NP mezipatro | K09.71224 | 4.NP mezipatro | 4039.99 | R-RS-LM4.04
71228 | 4.NP mezipatro | K09.71228 | 4.NP mezipatro | 3167.48 | R-RS-LM4.04
71231 | 4.NP mezipatro | K09.71231 | 4.NP mezipatro | 2319.71 | R-RS-LM4.04
71241 | 4.NP mezipatro | K09.71241 | 4.NP mezipatro | 3681.34 | R-RS-LM4.04
71246 | 4.NP mezipatro | K09.71246 | 4.NP mezipatro | 3448.64 | R-RS-LM4.04
71249 | 4.NP mezipatro | K09.71249 | 4.NP mezipatro | 1115.63 | R-RS-LM4.04
71254 | 4.NP mezipatro | K09.71254 | 4.NP mezipatro | 2350 | R-RS-LM4.04
71258 | 4.NP mezipatro | K09.71258 | 4.NP mezipatro | 140.72 | R-RS-LM4.04
71259 | 4.NP mezipatro | K09.71259 | 4.NP mezipatro | 241.42 | R-RS-LM4.04
71271 | 4.NP mezipatro | K09.71271 | 4.NP mezipatro | 3648.19 | R-RS-LM4.04
71274 | 4.NP mezipatro | K09.71274 | 4.NP mezipatro | 3466.11 | R-RS-LM4.04
71279 | 4.NP mezipatro | K09.71279 | 4.NP mezipatro | 2075.18 | R-RS-LM4.04
71283 | 4.NP mezipatro | K09.71283 | 4.NP mezipatro | 6412.38 | R-RS-LM4.04
71287 | 4.NP mezipatro | K09.71287 | 4.NP mezipatro | 120 | R-RS-LM4.04
71290 | 4.NP mezipatro | K09.71290 | 4.NP mezipatro | 3021.57 | R-RS-LM4.04
71298 | 4.NP mezipatro | K09.71298 | 4.NP mezipatro | 3655.76 | R-RS-LM4.04
71301 | 4.NP mezipatro | K09.71301 | 4.NP mezipatro | 1216.44 | R-RS-LM4.04
71306 | 4.NP mezipatro | K09.71306 | 4.NP mezipatro | 1772.75 | R-RS-LM4.04
71310 | 4.NP mezipatro | K09.71310 | 4.NP mezipatro | 120 | R-RS-LM4.04
71313 | 4.NP mezipatro | K09.71313 | 4.NP mezipatro | 7439.67 | R-RS-LM4.04
71320 | 4.NP mezipatro | K09.71320 | 4.NP mezipatro | 4460.91 | R-RS-LM4.04
71332 | 4.NP mezipatro | K09.71332 | 4.NP mezipatro | 3970 | R-RS-LM4.04
71337 | 4.NP mezipatro | K09.71337 | 4.NP mezipatro | 120 | R-RS-LM4.04
71340 | 4.NP mezipatro | K09.71340 | 4.NP mezipatro | 7402.19 | R-RS-LM4.04
71404 | 1.S | K09.71404 | 1.S | 136.39 | R-RS-LM1.05
71405 | 1.S | K09.71405 | 1.S | 1379.05 | R-RS-LM1.05
71408 | 1.S | K09.71408 | 1.S | 2353.79 | R-RS-LM1.05
71411 | 1.S | K09.71411 | 1.S | 7088.03 | R-RS-LM1.05
71414 | 1.S | K09.71414 | 1.S | 16126.5 | R-RS-LM1.05
71415 | 1.S | K09.71415 | 1.S | 890 | R-RS-LM1.05
71418 | 1.NP mezipatro | K09.71418 | 1.NP mezipatro | 2259.25 | R-RS-LM1.05
71419 | 1.NP mezipatro | K09.71419 | 1.NP mezipatro | 3750.95 | R-RS-LM1.05
71420 | 1.NP mezipatro | K09.71420 | 1.NP mezipatro | 2932.55 | R-RS-LM1.05
71422 | 1.NP mezipatro | K09.71422 | 1.NP mezipatro | 120 | R-RS-LM1.05
71424 | 1.NP mezipatro | K09.71424 | 1.NP mezipatro | 6963.63 | R-RS-LM1.05
71428 | 1.NP mezipatro | K09.71428 | 1.NP mezipatro | 2932.55 | R-RS-LM1.05
71430 | 1.NP mezipatro | K09.71430 | 1.NP mezipatro | 120 | R-RS-LM1.05
71432 | 1.NP mezipatro | K09.71432 | 1.NP mezipatro | 7282.48 | R-RS-LM1.05
71436 | 1.NP mezipatro | K09.71436 | 1.NP mezipatro | 1894.5 | R-RS-LM1.05
71437 | 1.NP mezipatro | K09.71437 | 1.NP mezipatro | 796.63 | R-RS-LM1.05
71438 | 1.NP mezipatro | K09.71438 | 1.NP mezipatro | 241.42 | R-RS-LM1.05
71449 | 1.NP mezipatro | K09.71449 | 1.NP mezipatro | 1650.75 | R-RS-LM1.05
71450 | 1.NP mezipatro | K09.71450 | 1.NP mezipatro | 182.99 | R-RS-LM1.05
71453 | 1.NP mezipatro | K09.71453 | 1.NP mezipatro | 5000 | R-RS-LM1.05
71456 | 1.NP mezipatro | K09.71456 | 1.NP mezipatro | 232.99 | R-RS-LM1.05
71466 | 1.NP mezipatro | K09.71466 | 1.NP mezipatro | 4852.25 | R-RS-LM1.05
71467 | 1.NP mezipatro | K09.71467 | 1.NP mezipatro | 146.66 | R-RS-LM1.05
71471 | 1.NP mezipatro | K09.71471 | 1.NP mezipatro | 1218.7 | R-RS-LM1.05
71474 | 1.NP mezipatro | K09.71474 | 1.NP mezipatro | 100.26 | R-RS-LM1.05
71477 | 1.NP mezipatro | K09.71477 | 1.NP mezipatro | 1298.59 | R-RS-LM1.05
71483 | 1.NP mezipatro | K09.71483 | 1.NP mezipatro | 60.52 | R-RS-LM1.05
71486 | 1.NP mezipatro | K09.71486 | 1.NP mezipatro | 34.72 | R-RS-LM1.05
71489 | 1.NP mezipatro | K09.71489 | 1.NP mezipatro | 3875 | R-RS-LM1.05
71492 | 1.NP mezipatro | K09.71492 | 1.NP mezipatro | 3969.62 | R-RS-LM1.05
71499 | 1.NP mezipatro | K09.71499 | 1.NP mezipatro | 4460 | R-RS-LM1.05
71512 | 1.NP mezipatro | K09.71512 | 1.NP mezipatro | 6211.72 | R-RS-LM1.05
71515 | 1.NP mezipatro | K09.71515 | 1.NP mezipatro | 120 | R-RS-LM1.05
71517 | 1.NP mezipatro | K09.71517 | 1.NP mezipatro | 1205.13 | R-RS-LM1.05
71522 | 1.NP mezipatro | K09.71522 | 1.NP mezipatro | 194.968 | R-RS-LM1.05
71523 | 1.NP mezipatro | K09.71523 | 1.NP mezipatro | 1446.13 | R-RS-LM1.05
71526 | 1.NP mezipatro | K09.71526 | 1.NP mezipatro | 4561.43 | R-RS-LM1.05
71527 | 1.NP mezipatro | K09.71527 | 1.NP mezipatro | 120 | R-RS-LM1.05
71529 | 1.NP mezipatro | K09.71529 | 1.NP mezipatro | 12159.9 | R-RS-LM1.05
71535 | 1.NP mezipatro | K09.71535 | 1.NP mezipatro | 1625.03 | R-RS-LM1.05
71538 | 1.NP mezipatro | K09.71538 | 1.NP mezipatro | 140.72 | R-RS-LM1.05
71539 | 1.NP mezipatro | K09.71539 | 1.NP mezipatro | 241.42 | R-RS-LM1.05
71561 | 1.NP mezipatro | K09.71561 | 1.NP mezipatro | 9939.34 | R-RS-LM1.05
71566 | 1.NP mezipatro | K09.71566 | 1.NP mezipatro | 1077.09 | R-RS-LM1.05
71568 | 1.NP mezipatro | K09.71568 | 1.NP mezipatro | 12358 | R-RS-LM1.05
71885 | 1.NP mezipatro | K09.71885 | 1.NP mezipatro | 4560 | R-RS-LM1.05
71898 | 1.NP mezipatro | K09.71898 | 1.NP mezipatro | 1985.46 | R-RS-LM1.05
71924 | 4.NP mezipatro | K09.71924 | 4.NP mezipatro | 1197.77 | R-RS-LM4.04
71936 | 4.NP mezipatro | K09.71936 | 4.NP mezipatro | 5169.54 | R-RS-LM4.04
71940 | 4.NP mezipatro | K09.71940 | 4.NP mezipatro | 145.72 | R-RS-LM4.04
71941 | 4.NP mezipatro | K09.71941 | 4.NP mezipatro | 241.42 | R-RS-LM4.04
71953 | 4.NP mezipatro | K09.71953 | 4.NP mezipatro | 1227.41 | R-RS-LM4.04
71956 | 4.NP mezipatro | K09.71956 | 4.NP mezipatro | 645.53 | R-RS-LM4.04
71965 | 4.NP mezipatro | K09.71965 | 4.NP mezipatro | 10911.2 | R-RS-LM4.04
71969 | 4.NP mezipatro | K09.71969 | 4.NP mezipatro | 120 | R-RS-LM4.04
71972 | 4.NP mezipatro | K09.71972 | 4.NP mezipatro | 4692.81 | R-RS-LM4.04
71980 | 4.NP mezipatro | K09.71980 | 4.NP mezipatro | 2055.74 | R-RS-LM4.04
71983 | 4.NP mezipatro | K09.71983 | 4.NP mezipatro | 2799.9 | R-RS-LM4.04
71988 | 4.NP mezipatro | K09.71988 | 4.NP mezipatro | 735.74 | R-RS-LM4.04
71992 | 4.NP mezipatro | K09.71992 | 4.NP mezipatro | 5712.38 | R-RS-LM4.04
71996 | 4.NP mezipatro | K09.71996 | 4.NP mezipatro | 2220 | R-RS-LM4.04
72000 | 4.NP mezipatro | K09.72000 | 4.NP mezipatro | 120 | R-RS-LM4.04
72003 | 4.NP mezipatro | K09.72003 | 4.NP mezipatro | 3025.2 | R-RS-LM4.04
72026 | 4.NP mezipatro | K09.72026 | 4.NP mezipatro | 6268.79 | R-RS-LM4.03
72034 | 4.NP mezipatro | K09.72034 | 4.NP mezipatro | 140.72 | R-RS-LM4.03
72035 | 4.NP mezipatro | K09.72035 | 4.NP mezipatro | 241.42 | R-RS-LM4.03
72047 | 4.NP mezipatro | K09.72047 | 4.NP mezipatro | 120 | R-RS-LM4.03
72050 | 4.NP mezipatro | K09.72050 | 4.NP mezipatro | 4208.27 | R-RS-LM4.03
74268 | 1.NP | K09.74268 | 1.NP | 4060.56 | R-RS-LM1.13
74269 | 1.NP | K09.74269 | 1.NP | 1023.99 | R-RS-LM1.13
74270 | 1.NP | K09.74270 | 1.NP | 12204.1 | R-RS-LM1.13
74273 | 1.NP | K09.74273 | 1.NP | 33271.5 | R-RS-LM1.13
74274 | 1.NP | K09.74274 | 1.NP | 3739.74 | R-RS-LM1.13
74275 | 1.NP | K09.74275 | 1.NP | 2999.97 | R-RS-LM1.13
74276 | 1.NP | K09.74276 | 1.NP | 3264.31 | R-RS-LM1.13
74277 | 1.NP | K09.74277 | 1.NP | 7298.63 | R-RS-LM1.13
74279 | 1.NP | K09.74279 | 1.NP | 1013.17 | R-RS-LM1.13
74280 | 1.NP | K09.74280 | 1.NP | 863.53 | R-RS-LM1.13
74281 | 1.NP | K09.74281 | 1.NP | 1013.17 | R-RS-LM1.13
74283 | 1.NP | K09.74283 | 1.NP | 4894.24 | R-RS-LM1.13
74284 | 1.NP | K09.74284 | 1.NP | 12169.8 | R-RS-LM1.13
74285 | 1.NP | K09.74285 | 1.NP | 7440 | R-RS-LM1.13
74288 | 1.NP | K09.74288 | 1.NP | 5114.99 | R-RS-LM1.13
74289 | 1.NP | K09.74289 | 1.NP | 105.047 | R-RS-LM1.13
74290 | 1.NP | K09.74290 | 1.NP | 78.89 | R-RS-LM1.13
74291 | 1.NP | K09.74291 | 1.NP | 4910 | R-RS-LM1.13
74296 | 1.NP | K09.74296 | 1.NP | 4180.23 | R-RS-LM1.13
74298 | 1.NP | K09.74298 | 1.NP | 1471.78 | R-RS-LM1.13
74299 | 1.NP | K09.74299 | 1.NP | 3162.85 | R-RS-LM1.13
74310 | 1.NP | K09.74310 | 1.NP | 5502.38 | R-RS-LM1.13
74313 | 1.NP | K09.74313 | 1.NP | 1587.27 | R-RS-LM1.13
74322 | 1.NP | K09.74322 | 1.NP | 3719.8 | R-RS-LM1.13
74323 | 1.NP | K09.74323 | 1.NP | 120.75 | R-RS-LM1.13
74324 | 1.NP | K09.74324 | 1.NP | 7750 | R-RS-LM1.13
74331 | 1.NP | K09.74331 | 1.NP | 3968.53 | R-RS-LM1.13
74337 | 1.NP | K09.74337 | 1.NP | 2960 | R-RS-LM1.13
74338 | 1.NP | K09.74338 | 1.NP | 120 | R-RS-LM1.13
74344 | 1.NP | K09.74344 | 1.NP | 120 | R-RS-LM1.13
74351 | 1.NP | K09.74351 | 1.NP | 1938.27 | R-RS-LM1.13
74352 | 1.NP | K09.74352 | 1.NP | 241.42 | R-RS-LM1.13
74361 | 1.NP | K09.74361 | 1.NP | 120 | R-RS-LM1.13
74363 | 1.NP | K09.74363 | 1.NP | 2062.32 | R-RS-LM1.13
74370 | 1.NP | K09.74370 | 1.NP | 120 | R-RS-LM1.13
74372 | 1.NP | K09.74372 | 1.NP | 10375 | R-RS-LM1.13
74387 | 1.NP | K09.74387 | 1.NP | 120 | R-RS-LM1.13
74389 | 1.NP | K09.74389 | 1.NP | 8018.32 | R-RS-LM1.13
74394 | 1.NP | K09.74394 | 1.NP | 293.68 | R-RS-LM1.13
74395 | 1.NP | K09.74395 | 1.NP | 241.42 | R-RS-LM1.13
74405 | 1.S | K09.74405 | 1.S | 166.39 | R-RS-LM1.13
74406 | 1.S | K09.74406 | 1.S | 1349.05 | R-RS-LM1.13
74409 | 1.S | K09.74409 | 1.S | 2278.79 | R-RS-LM1.13
74412 | 1.S | K09.74412 | 1.S | 7013.03 | R-RS-LM1.13
74415 | 1.S | K09.74415 | 1.S | 16081.5 | R-RS-LM1.13
74416 | 1.S | K09.74416 | 1.S | 890 | R-RS-LM1.13
74422 | 1.NP | K09.74422 | 1.NP | 6247.19 | R-RS-LM1.13
74704 | 2.NP | K09.74704 | 2.NP | 6352.64 | R-RS-LM2.13
74808 | 2.NP | K09.74808 | 2.NP | 5940 | R-RS-LM2.13
74809 | 1.S | K09.74809 | 1.S | 166.39 | R-RS-LM2.13
74810 | 1.S | K09.74810 | 1.S | 1349.05 | R-RS-LM2.13
74813 | 1.S | K09.74813 | 1.S | 2278.79 | R-RS-LM2.13
74816 | 1.S | K09.74816 | 1.S | 7058.13 | R-RS-LM2.13
74819 | 1.S | K09.74819 | 1.S | 16061.5 | R-RS-LM2.13
74820 | 1.S | K09.74820 | 1.S | 910 | R-RS-LM2.13
75031 | 2.NP | K09.75031 | 2.NP | 4051.48 | R-RS-LM2.13
75375 | 3.NP mezipatro | K09.75375 | 3.NP mezipatro | 1509.63 | R-RS-LM3.03
75376 | 3.NP mezipatro | K09.75376 | 3.NP mezipatro | 1698.59 | R-RS-LM3.03
75377 | 3.NP mezipatro | K09.75377 | 3.NP mezipatro | 4000 | R-RS-LM3.03
75380 | 3.NP mezipatro | K09.75380 | 3.NP mezipatro | 1900 | R-RS-LM3.03
75381 | 3.NP mezipatro | K09.75381 | 3.NP mezipatro | 350 | R-RS-LM3.03
75384 | 3.NP mezipatro | K09.75384 | 3.NP mezipatro | 621.016 | R-RS-LM3.03
75385 | 3.NP mezipatro | K09.75385 | 3.NP mezipatro | 2591.24 | R-RS-LM3.03
75386 | 3.NP mezipatro | K09.75386 | 3.NP mezipatro | 3641.84 | R-RS-LM3.03
75388 | 3.NP mezipatro | K09.75388 | 3.NP mezipatro | 1816.24 | R-RS-LM3.03
75391 | 3.NP mezipatro | K09.75391 | 3.NP mezipatro | 3432.61 | R-RS-LM3.03
75394 | 3.NP mezipatro | K09.75394 | 3.NP mezipatro | 3292.86 | R-RS-LM3.03
75395 | 3.NP mezipatro | K09.75395 | 3.NP mezipatro | 958.6 | R-RS-LM3.03
75396 | 3.NP mezipatro | K09.75396 | 3.NP mezipatro | 3983.16 | R-RS-LM3.03
75399 | 3.NP mezipatro | K09.75399 | 3.NP mezipatro | 841.9 | R-RS-LM3.03
75402 | 3.NP mezipatro | K09.75402 | 3.NP mezipatro | 1632.47 | R-RS-LM3.03
75404 | 3.NP mezipatro | K09.75404 | 3.NP mezipatro | 343.28 | R-RS-LM3.03
75407 | 3.NP mezipatro | K09.75407 | 3.NP mezipatro | 5997.93 | R-RS-LM3.03
75410 | 3.NP mezipatro | K09.75410 | 3.NP mezipatro | 393.28 | R-RS-LM3.03
75413 | 3.NP mezipatro | K09.75413 | 3.NP mezipatro | 2937.73 | R-RS-LM3.03
75414 | 3.NP mezipatro | K09.75414 | 3.NP mezipatro | 1657.35 | R-RS-LM3.03
75417 | 3.NP mezipatro | K09.75417 | 3.NP mezipatro | 4257.3 | R-RS-LM3.03
75424 | 3.NP mezipatro | K09.75424 | 3.NP mezipatro | 1032.9 | R-RS-LM3.03
75425 | 3.NP mezipatro | K09.75425 | 3.NP mezipatro | 120 | R-RS-LM3.03
75427 | 3.NP mezipatro | K09.75427 | 3.NP mezipatro | 287.7 | R-RS-LM3.03
75432 | 3.NP mezipatro | K09.75432 | 3.NP mezipatro | 1882.64 | R-RS-LM3.03
75435 | 3.NP mezipatro | K09.75435 | 3.NP mezipatro | 12962.4 | R-RS-LM3.03
75436 | 3.NP mezipatro | K09.75436 | 3.NP mezipatro | 7914.35 | R-RS-LM3.03
75439 | 3.NP mezipatro | K09.75439 | 3.NP mezipatro | 3154.34 | R-RS-LM3.03
75442 | 3.NP mezipatro | K09.75442 | 3.NP mezipatro | 140.72 | R-RS-LM3.03
75443 | 3.NP mezipatro | K09.75443 | 3.NP mezipatro | 241.42 | R-RS-LM3.03
75453 | 3.NP mezipatro | K09.75453 | 3.NP mezipatro | 3536.48 | R-RS-LM3.03
75456 | 3.NP mezipatro | K09.75456 | 3.NP mezipatro | 120 | R-RS-LM3.03
75458 | 3.NP mezipatro | K09.75458 | 3.NP mezipatro | 8638.23 | R-RS-LM3.03
75464 | 3.NP mezipatro | K09.75464 | 3.NP mezipatro | 3536.48 | R-RS-LM3.03
75465 | 3.NP mezipatro | K09.75465 | 3.NP mezipatro | 2194.71 | R-RS-LM3.03
75466 | 3.NP mezipatro | K09.75466 | 3.NP mezipatro | 1900 | R-RS-LM3.03
75467 | 3.NP mezipatro | K09.75467 | 3.NP mezipatro | 5142.5 | R-RS-LM3.03
75473 | 3.NP mezipatro | K09.75473 | 3.NP mezipatro | 120 | R-RS-LM3.03
75475 | 3.NP mezipatro | K09.75475 | 3.NP mezipatro | 25136.6 | R-RS-LM3.03
75482 | 3.NP mezipatro | K09.75482 | 3.NP mezipatro | 897.61 | R-RS-LM3.03
75485 | 3.NP mezipatro | K09.75485 | 3.NP mezipatro | 4087.15 | R-RS-LM3.03
75487 | 1.S | K09.75487 | 1.S | 151.39 | R-RS-LM3.03
75488 | 1.S | K09.75488 | 1.S | 1379.05 | R-RS-LM3.03
75491 | 1.S | K09.75491 | 1.S | 2338.79 | R-RS-LM3.03
75494 | 1.S | K09.75494 | 1.S | 6946.53 | R-RS-LM3.03
75497 | 1.S | K09.75497 | 1.S | 16086.5 | R-RS-LM3.03
75501 | 3.NP mezipatro | K09.75501 | 3.NP mezipatro | 10420 | R-RS-LM3.03
75505 | 1.S | K09.75505 | 1.S | 930 | R-RS-LM3.03
75508 | 3.NP mezipatro | K09.75508 | 3.NP mezipatro | 2298.79 | R-RS-LM3.03
75519 | 3.NP mezipatro | K09.75519 | 3.NP mezipatro | 6288.66 | R-RS-LM3.03
75523 | 3.NP mezipatro | K09.75523 | 3.NP mezipatro | 140.72 | R-RS-LM3.03
75524 | 3.NP mezipatro | K09.75524 | 3.NP mezipatro | 241.42 | R-RS-LM3.03
75702 | 3.NP mezipatro | K09.75702 | 3.NP mezipatro | 524.44 | R-RS-LM3.03
75713 | 3.NP mezipatro | K09.75713 | 3.NP mezipatro | 4047.53 | R-RS-LM3.03
76098 | 3.NP mezipatro | K09.76098 | 3.NP mezipatro | 2571.26 | R-RS-LM3.03
76489 | 1.S | K09.76489 | 1.S | 151.39 | R-RS-LM3.04
76490 | 1.S | K09.76490 | 1.S | 1379.05 | R-RS-LM3.04
76493 | 1.S | K09.76493 | 1.S | 2353.79 | R-RS-LM3.04
76496 | 1.S | K09.76496 | 1.S | 6961.53 | R-RS-LM3.04
76499 | 1.S | K09.76499 | 1.S | 16101.5 | R-RS-LM3.04
76502 | 1.S | K09.76502 | 1.S | 930 | R-RS-LM3.04
76505 | 3.NP mezipatro | K09.76505 | 3.NP mezipatro | 2313.79 | R-RS-LM3.04
76506 | 3.NP mezipatro | K09.76506 | 3.NP mezipatro | 3016.72 | R-RS-LM3.04
76507 | 3.NP mezipatro | K09.76507 | 3.NP mezipatro | 347.65 | R-RS-LM3.04
76508 | 3.NP mezipatro | K09.76508 | 3.NP mezipatro | 3850 | R-RS-LM3.04
76510 | 3.NP mezipatro | K09.76510 | 3.NP mezipatro | 120 | R-RS-LM3.04
76512 | 3.NP mezipatro | K09.76512 | 3.NP mezipatro | 7413.73 | R-RS-LM3.04
76516 | 3.NP mezipatro | K09.76516 | 3.NP mezipatro | 3850 | R-RS-LM3.04
76518 | 3.NP mezipatro | K09.76518 | 3.NP mezipatro | 120 | R-RS-LM3.04
76520 | 3.NP mezipatro | K09.76520 | 3.NP mezipatro | 6204.07 | R-RS-LM3.04
76523 | 3.NP mezipatro | K09.76523 | 3.NP mezipatro | 2589.03 | R-RS-LM3.04
76524 | 3.NP mezipatro | K09.76524 | 3.NP mezipatro | 1959.24 | R-RS-LM3.04
76527 | 3.NP mezipatro | K09.76527 | 3.NP mezipatro | 1640 | R-RS-LM3.04
76528 | 3.NP mezipatro | K09.76528 | 3.NP mezipatro | 2432.91 | R-RS-LM3.04
76535 | 3.NP mezipatro | K09.76535 | 3.NP mezipatro | 5090.66 | R-RS-LM3.04
76543 | 3.NP mezipatro | K09.76543 | 3.NP mezipatro | 6075.41 | R-RS-LM3.04
76544 | 3.NP mezipatro | K09.76544 | 3.NP mezipatro | 1046.41 | R-RS-LM3.04
76545 | 3.NP mezipatro | K09.76545 | 3.NP mezipatro | 175.974 | R-RS-LM3.04
76546 | 3.NP mezipatro | K09.76546 | 3.NP mezipatro | 1858.7 | R-RS-LM3.04
76549 | 3.NP mezipatro | K09.76549 | 3.NP mezipatro | 383.76 | R-RS-LM3.04
76552 | 3.NP mezipatro | K09.76552 | 3.NP mezipatro | 1898.59 | R-RS-LM3.04
76558 | 3.NP mezipatro | K09.76558 | 3.NP mezipatro | 1972.91 | R-RS-LM3.04
76561 | 3.NP mezipatro | K09.76561 | 3.NP mezipatro | 1898.59 | R-RS-LM3.04
76564 | 3.NP mezipatro | K09.76564 | 3.NP mezipatro | 4922.91 | R-RS-LM3.04
76567 | 3.NP mezipatro | K09.76567 | 3.NP mezipatro | 3970 | R-RS-LM3.04
76571 | 3.NP mezipatro | K09.76571 | 3.NP mezipatro | 6304.5 | R-RS-LM3.04
76574 | 3.NP mezipatro | K09.76574 | 3.NP mezipatro | 1019.55 | R-RS-LM3.04
76575 | 3.NP mezipatro | K09.76575 | 3.NP mezipatro | 241.42 | R-RS-LM3.04
76586 | 3.NP mezipatro | K09.76586 | 3.NP mezipatro | 897.61 | R-RS-LM3.04
76587 | 3.NP mezipatro | K09.76587 | 3.NP mezipatro | 13260.9 | R-RS-LM3.04
76593 | 3.NP mezipatro | K09.76593 | 3.NP mezipatro | 120 | R-RS-LM3.04
76595 | 3.NP mezipatro | K09.76595 | 3.NP mezipatro | 2390.91 | R-RS-LM3.04
76602 | 3.NP mezipatro | K09.76602 | 3.NP mezipatro | 5675.54 | R-RS-LM3.04
76607 | 3.NP mezipatro | K09.76607 | 3.NP mezipatro | 2218.59 | R-RS-LM3.04
76608 | 3.NP mezipatro | K09.76608 | 3.NP mezipatro | 1672.35 | R-RS-LM3.04
76611 | 3.NP mezipatro | K09.76611 | 3.NP mezipatro | 1615.72 | R-RS-LM3.04
76612 | 3.NP mezipatro | K09.76612 | 3.NP mezipatro | 241.42 | R-RS-LM3.04
76621 | 3.NP mezipatro | K09.76621 | 3.NP mezipatro | 120 | R-RS-LM3.04
76623 | 3.NP mezipatro | K09.76623 | 3.NP mezipatro | 3550.64 | R-RS-LM3.04
76632 | 3.NP mezipatro | K09.76632 | 3.NP mezipatro | 10367.4 | R-RS-LM3.04
76648 | 3.NP mezipatro | K09.76648 | 3.NP mezipatro | 10132 | R-RS-LM3.04
76651 | 3.NP mezipatro | K09.76651 | 3.NP mezipatro | 10420 | R-RS-LM3.04
78846 | 1.NP mezipatro | K09.78846 | 1.NP mezipatro | 2422.01 | R-RS-LM1.06
78847 | 1.NP mezipatro | K09.78847 | 1.NP mezipatro | 1231.17 | R-RS-LM1.06
78848 | 1.NP mezipatro | K09.78848 | 1.NP mezipatro | 4912.38 | R-RS-LM1.06
78851 | 1.NP mezipatro | K09.78851 | 1.NP mezipatro | 2136.11 | R-RS-LM1.06
78852 | 1.NP mezipatro | K09.78852 | 1.NP mezipatro | 350 | R-RS-LM1.06
78855 | 1.NP mezipatro | K09.78855 | 1.NP mezipatro | 621.016 | R-RS-LM1.06
78856 | 1.NP mezipatro | K09.78856 | 1.NP mezipatro | 4329.36 | R-RS-LM1.06
78857 | 1.NP mezipatro | K09.78857 | 1.NP mezipatro | 3641.84 | R-RS-LM1.06
78859 | 1.NP mezipatro | K09.78859 | 1.NP mezipatro | 186.997 | R-RS-LM1.06
78862 | 1.NP mezipatro | K09.78862 | 1.NP mezipatro | 7690 | R-RS-LM1.06
78865 | 1.NP mezipatro | K09.78865 | 1.NP mezipatro | 3117.86 | R-RS-LM1.06
78866 | 1.NP mezipatro | K09.78866 | 1.NP mezipatro | 808.6 | R-RS-LM1.06
78867 | 1.NP mezipatro | K09.78867 | 1.NP mezipatro | 3125 | R-RS-LM1.06
78870 | 1.NP mezipatro | K09.78870 | 1.NP mezipatro | 991.9 | R-RS-LM1.06
78875 | 1.NP mezipatro | K09.78875 | 1.NP mezipatro | 123.61 | R-RS-LM1.06
78876 | 1.NP mezipatro | K09.78876 | 1.NP mezipatro | 5997.93 | R-RS-LM1.06
78879 | 1.NP mezipatro | K09.78879 | 1.NP mezipatro | 173.25 | R-RS-LM1.06
78882 | 1.NP mezipatro | K09.78882 | 1.NP mezipatro | 19644.9 | R-RS-LM1.06
78883 | 1.NP mezipatro | K09.78883 | 1.NP mezipatro | 1639.67 | R-RS-LM1.06
78884 | 1.NP mezipatro | K09.78884 | 1.NP mezipatro | 120 | R-RS-LM1.06
78895 | 1.NP mezipatro | K09.78895 | 1.NP mezipatro | 4719.75 | R-RS-LM1.06
78900 | 1.NP mezipatro | K09.78900 | 1.NP mezipatro | 223.029 | R-RS-LM1.06
78903 | 1.NP mezipatro | K09.78903 | 1.NP mezipatro | 12347.8 | R-RS-LM1.06
78904 | 1.NP mezipatro | K09.78904 | 1.NP mezipatro | 7914.35 | R-RS-LM1.06
78907 | 1.NP mezipatro | K09.78907 | 1.NP mezipatro | 2288.35 | R-RS-LM1.06
78910 | 1.NP mezipatro | K09.78910 | 1.NP mezipatro | 140.72 | R-RS-LM1.06
78911 | 1.NP mezipatro | K09.78911 | 1.NP mezipatro | 241.42 | R-RS-LM1.06
78921 | 1.NP mezipatro | K09.78921 | 1.NP mezipatro | 3635.43 | R-RS-LM1.06
78924 | 1.NP mezipatro | K09.78924 | 1.NP mezipatro | 120 | R-RS-LM1.06
78926 | 1.NP mezipatro | K09.78926 | 1.NP mezipatro | 8638.23 | R-RS-LM1.06
78932 | 1.NP mezipatro | K09.78932 | 1.NP mezipatro | 2737.5 | R-RS-LM1.06
78933 | 1.NP mezipatro | K09.78933 | 1.NP mezipatro | 2194.71 | R-RS-LM1.06
78934 | 1.NP mezipatro | K09.78934 | 1.NP mezipatro | 1618.18 | R-RS-LM1.06
78935 | 1.NP mezipatro | K09.78935 | 1.NP mezipatro | 5142.5 | R-RS-LM1.06
78941 | 1.NP mezipatro | K09.78941 | 1.NP mezipatro | 120 | R-RS-LM1.06
78943 | 1.NP mezipatro | K09.78943 | 1.NP mezipatro | 25097.6 | R-RS-LM1.06
78949 | 1.NP mezipatro | K09.78949 | 1.NP mezipatro | 1077.09 | R-RS-LM1.06
78952 | 1.NP mezipatro | K09.78952 | 1.NP mezipatro | 4088.78 | R-RS-LM1.06
78954 | 1.S | K09.78954 | 1.S | 121.39 | R-RS-LM1.06
78955 | 1.S | K09.78955 | 1.S | 1394.05 | R-RS-LM1.06
78958 | 1.S | K09.78958 | 1.S | 2383.79 | R-RS-LM1.06
78961 | 1.S | K09.78961 | 1.S | 7118.03 | R-RS-LM1.06
78964 | 1.S | K09.78964 | 1.S | 16141.5 | R-RS-LM1.06
78967 | 1.NP mezipatro | K09.78967 | 1.NP mezipatro | 4460 | R-RS-LM1.06
78968 | 1.S | K09.78968 | 1.S | 890 | R-RS-LM1.06
78971 | 1.NP mezipatro | K09.78971 | 1.NP mezipatro | 2274.48 | R-RS-LM1.06
78977 | 1.NP mezipatro | K09.78977 | 1.NP mezipatro | 6226.72 | R-RS-LM1.06
78981 | 1.NP mezipatro | K09.78981 | 1.NP mezipatro | 105.72 | R-RS-LM1.06
78982 | 1.NP mezipatro | K09.78982 | 1.NP mezipatro | 241.42 | R-RS-LM1.06
78992 | 1.NP mezipatro | K09.78992 | 1.NP mezipatro | 120 | R-RS-LM1.06
78994 | 1.NP mezipatro | K09.78994 | 1.NP mezipatro | 4060.09 | R-RS-LM1.06
79000 | 1.NP mezipatro | K09.79000 | 1.NP mezipatro | 1944.54 | R-RS-LM1.06
79004 | 1.NP mezipatro | K09.79004 | 1.NP mezipatro | 3955.23 | R-RS-LM1.06
79019 | 1.NP mezipatro | K09.79019 | 1.NP mezipatro | 2579.93 | R-RS-LM1.06
79178 | 1.NP mezipatro | K09.79178 | 1.NP mezipatro | 2262.3 | R-RS-LM1.06
79181 | 1.NP mezipatro | K09.79181 | 1.NP mezipatro | 120 | R-RS-LM1.06
79184 | 1.NP mezipatro | K09.79184 | 1.NP mezipatro | 214.26 | R-RS-LM1.06
79189 | 1.NP mezipatro | K09.79189 | 1.NP mezipatro | 1485.63 | R-RS-LM1.06
79209 | 1.NP mezipatro | K09.79209 | 1.NP mezipatro | 500 | R-RS-LM1.06
79213 | 1.NP mezipatro | K09.79213 | 1.NP mezipatro | 222.32 | R-RS-LM1.06
79218 | 1.NP mezipatro | K09.79218 | 1.NP mezipatro | 610 | R-RS-LM1.06
79222 | 1.NP mezipatro | K09.79222 | 1.NP mezipatro | 2644.84 | R-RS-LM1.06
79242 | 1.NP mezipatro | K09.79242 | 1.NP mezipatro | 5840.85 | R-RS-LM1.06
79385 | 1.NP mezipatro | K09.79385 | 1.NP mezipatro | 120 | R-RS-LM1.06
79388 | 1.NP mezipatro | K09.79388 | 1.NP mezipatro | 2929.06 | R-RS-LM1.06
79481 | 1.NP mezipatro | K09.79481 | 1.NP mezipatro | 276.56 | R-RS-LM1.06
79514 | 1.NP mezipatro | K09.79514 | 1.NP mezipatro | 1360 | R-RS-LM1.06
79574 | 1.NP mezipatro | K09.79574 | 1.NP mezipatro | 216.56 | R-RS-LM1.06
79586 | 1.NP mezipatro | K09.79586 | 1.NP mezipatro | 3520 | R-RS-LM1.06
79636 | 1.NP mezipatro | K09.79636 | 1.NP mezipatro | 250 | R-RS-LM1.06
84058 | 1.S | K09.84058 | 1.S | 1250 | R-RS-LM0.01
84253 | 1.S | K09.84253 | 1.S | 483.5 | R-RS-LM0.02
84256 | 1.S | K09.84256 | 1.S | 4944.07 | R-RS-LM0.02
84259 | 1.S | K09.84259 | 1.S | 2269.35 | R-RS-LM0.02
84264 | 1.S | K09.84264 | 1.S | 1274.07 | R-RS-LM0.02
84345 | 1.S | K09.84345 | 1.S | 1258.13 | R-RS-LM0.02
84373 | 1.S | K09.84373 | 1.S | 109.65 | R-RS-LM0.02
84465 | 1.S | K09.84465 | 1.S | 1383.07 | R-RS-LM0.03
84492 | 1.S | K09.84492 | 1.S | 6742.03 | R-RS-LM0.03
84493 | 1.S | K09.84493 | 1.S | 2146.57 | R-RS-LM0.03
84494 | 1.S | K09.84494 | 1.S | 1253.05 | R-RS-LM0.03
84508 | 1.S | K09.84508 | 1.S | 1178.41 | R-RS-LM0.03
84509 | 1.S | K09.84509 | 1.S | 133.019 | R-RS-LM0.03
84579 | 1.S | K09.84579 | 1.S | 3323.24 | R-RS-LM0.03
84693 | 1.S | K09.84693 | 1.S | 14.6 | R-RS-LM0.03
84694 | 1.S | K09.84694 | 1.S | 354.56 | R-RS-LM0.03
84708 | 1.S | K09.84708 | 1.S | 1418.05 | R-RS-LM1.01
84709 | 1.S | K09.84709 | 1.S | 2476.57 | R-RS-LM1.01
84712 | 1.S | K09.84712 | 1.S | 7087.03 | R-RS-LM1.01
84715 | 1.S | K09.84715 | 1.S | 68.022 | R-RS-LM1.01
84718 | 1.S | K09.84718 | 1.S | 1170 | R-RS-LM1.01
84809 | 1.S | K09.84809 | 1.S | 7840.59 | R-RS-LM1.01
84813 | 1.S | K09.84813 | 1.S | 34491 | R-RS-LM1.01
84817 | 1.S | K09.84817 | 1.S | 4087.59 | R-RS-LM1.01
84996 | 1.S | K09.84996 | 1.S | 2060 | R-RS-LM1.01
85006 | 1.S | K09.85006 | 1.S | 3497.41 | R-RS-LM1.01
85112 | 1.S | K09.85112 | 1.S | 989.21 | R-RS-LM0.01
85115 | 1.S | K09.85115 | 1.S | 2160.03 | R-RS-LM0.01
85124 | 1.S | K09.85124 | 1.S | 198.094 | R-RS-LM0.01
85129 | 1.S | K09.85129 | 1.S | 359.006 | R-RS-LM0.01
85132 | 1.S | K09.85132 | 1.S | 120 | R-RS-LM0.01
85135 | 1.S | K09.85135 | 1.S | 2640 | R-RS-LM0.01
85140 | 1.S | K09.85140 | 1.S | 359.005 | R-RS-LM0.01
85161 | 1.S | K09.85161 | 1.S | 572.071 | R-RS-LM0.01
85798 | 1.S | K09.85798 | 1.S | 1383.07 | R-RS-LM0.04
85799 | 1.S | K09.85799 | 1.S | 6772.03 | R-RS-LM0.04
85800 | 1.S | K09.85800 | 1.S | 2176.57 | R-RS-LM0.04
85801 | 1.S | K09.85801 | 1.S | 1268.05 | R-RS-LM0.04
85804 | 1.S | K09.85804 | 1.S | 1178.41 | R-RS-LM0.04
85805 | 1.S | K09.85805 | 1.S | 118.019 | R-RS-LM0.04
85810 | 1.S | K09.85810 | 1.S | 5400.14 | R-RS-LM0.04
85815 | 1.S | K09.85815 | 1.S | 29.6 | R-RS-LM0.04
85816 | 1.S | K09.85816 | 1.S | 354.56 | R-RS-LM0.04
85849 | 1.S | K09.85849 | 1.S | 1525.12 | R-RS-LM0.04
85859 | 1.S | K09.85859 | 1.S | 1258.13 | R-RS-LM0.05
85860 | 1.S | K09.85860 | 1.S | 109.65 | R-RS-LM0.05
85915 | 1.S | K09.85915 | 1.S | 1050 | R-RS-LM0.05
85918 | 1.S | K09.85918 | 1.S | 875.66 | R-RS-LM0.05
85923 | 1.S | K09.85923 | 1.S | 1313.34 | R-RS-LM0.05
85927 | 1.S | K09.85927 | 1.S | 1458.48 | R-RS-LM0.05
86043 | 5.NP | K09.86043 | 5.NP | 420 | R-RS-LM1.01
86045 | 5.NP | K09.86045 | 5.NP | 2390.19 | R-RS-LM1.01
86047 | 5.NP | K09.86047 | 5.NP | 2300 | R-RS-LM1.01
86049 | 5.NP | K09.86049 | 5.NP | 600 | R-RS-LM1.01
86053 | 5.NP | K09.86053 | 5.NP | 860 | R-RS-LM1.01
86057 | 5.NP | K09.86057 | 5.NP | 160 | R-RS-LM1.01
86061 | 5.NP | K09.86061 | 5.NP | 2200 | R-RS-LM1.01
86065 | 5.NP | K09.86065 | 5.NP | 190 | R-RS-LM1.01
86069 | 5.NP | K09.86069 | 5.NP | 2300 | R-RS-LM1.01
86070 | 5.NP | K09.86070 | 5.NP | 645.19 | R-RS-LM1.01
86073 | 5.NP | K09.86073 | 5.NP | 860 | R-RS-LM1.01
86076 | 5.NP | K09.86076 | 5.NP | 114.81 | R-RS-LM1.01
86079 | 5.NP | K09.86079 | 5.NP | 2200 | R-RS-LM1.01
86082 | 5.NP | K09.86082 | 5.NP | 164.81 | R-RS-LM1.01
86098 | 5.NP | K09.86098 | 5.NP | 3020 | R-RS-LM1.01
86103 | 4.NP mezipatro | K09.86103 | 4.NP mezipatro | 1470.19 | R-RS-LM1.01
86104 | 4.NP mezipatro | K09.86104 | 4.NP mezipatro | 2300 | R-RS-LM1.01
86105 | 4.NP mezipatro | K09.86105 | 4.NP mezipatro | 645.19 | R-RS-LM1.01
86108 | 4.NP mezipatro | K09.86108 | 4.NP mezipatro | 860 | R-RS-LM1.01
86111 | 4.NP mezipatro | K09.86111 | 4.NP mezipatro | 114.81 | R-RS-LM1.01
86114 | 4.NP mezipatro | K09.86114 | 4.NP mezipatro | 2200 | R-RS-LM1.01
86117 | 4.NP mezipatro | K09.86117 | 4.NP mezipatro | 164.81 | R-RS-LM1.01
86129 | 1.S mezipatro | K09.86129 | 1.S mezipatro | 1934.52 | R-RS-LM1.01
86130 | 1.S mezipatro | K09.86130 | 1.S mezipatro | 2300 | R-RS-LM1.01
86131 | 1.S mezipatro | K09.86131 | 1.S mezipatro | 645.19 | R-RS-LM1.01
86134 | 1.S mezipatro | K09.86134 | 1.S mezipatro | 860 | R-RS-LM1.01
86137 | 1.S mezipatro | K09.86137 | 1.S mezipatro | 114.81 | R-RS-LM1.01
86140 | 1.S mezipatro | K09.86140 | 1.S mezipatro | 2200 | R-RS-LM1.01
86143 | 1.S mezipatro | K09.86143 | 1.S mezipatro | 164.81 | R-RS-LM1.01
86155 | 2.NP mezipatro | K09.86155 | 2.NP mezipatro | 1984.52 | R-RS-LM1.01
86156 | 2.NP mezipatro | K09.86156 | 2.NP mezipatro | 2300 | R-RS-LM1.01
86157 | 2.NP mezipatro | K09.86157 | 2.NP mezipatro | 645.19 | R-RS-LM1.01
86160 | 2.NP mezipatro | K09.86160 | 2.NP mezipatro | 860 | R-RS-LM1.01
86163 | 2.NP mezipatro | K09.86163 | 2.NP mezipatro | 114.81 | R-RS-LM1.01
86166 | 2.NP mezipatro | K09.86166 | 2.NP mezipatro | 2200 | R-RS-LM1.01
86169 | 2.NP mezipatro | K09.86169 | 2.NP mezipatro | 164.81 | R-RS-LM1.01
86181 | 3.NP mezipatro | K09.86181 | 3.NP mezipatro | 1934.52 | R-RS-LM1.01
86182 | 3.NP mezipatro | K09.86182 | 3.NP mezipatro | 2300 | R-RS-LM1.01
86183 | 3.NP mezipatro | K09.86183 | 3.NP mezipatro | 645.19 | R-RS-LM1.01
86186 | 3.NP mezipatro | K09.86186 | 3.NP mezipatro | 860 | R-RS-LM1.01
86189 | 3.NP mezipatro | K09.86189 | 3.NP mezipatro | 114.81 | R-RS-LM1.01
86192 | 3.NP mezipatro | K09.86192 | 3.NP mezipatro | 2200 | R-RS-LM1.01
86195 | 3.NP mezipatro | K09.86195 | 3.NP mezipatro | 164.81 | R-RS-LM1.01
86207 | 1.NP mezipatro | K09.86207 | 1.NP mezipatro | 1934.52 | R-RS-LM1.01
86208 | 1.NP mezipatro | K09.86208 | 1.NP mezipatro | 2300 | R-RS-LM1.01
86209 | 1.NP mezipatro | K09.86209 | 1.NP mezipatro | 645.19 | R-RS-LM1.01
86212 | 1.NP mezipatro | K09.86212 | 1.NP mezipatro | 860 | R-RS-LM1.01
86215 | 1.NP mezipatro | K09.86215 | 1.NP mezipatro | 114.81 | R-RS-LM1.01
86218 | 1.NP mezipatro | K09.86218 | 1.NP mezipatro | 2200 | R-RS-LM1.01
86221 | 1.NP mezipatro | K09.86221 | 1.NP mezipatro | 164.81 | R-RS-LM1.01
86233 | 4.NP | K09.86233 | 4.NP | 2300 | R-RS-LM1.01
86234 | 4.NP | K09.86234 | 4.NP | 600 | R-RS-LM1.01
86237 | 4.NP | K09.86237 | 4.NP | 860 | R-RS-LM1.01
86240 | 4.NP | K09.86240 | 4.NP | 160 | R-RS-LM1.01
86243 | 4.NP | K09.86243 | 4.NP | 2200 | R-RS-LM1.01
86246 | 4.NP | K09.86246 | 4.NP | 190 | R-RS-LM1.01
86251 | 4.NP | K09.86251 | 4.NP | 1314.51 | R-RS-LM1.01
86259 | 1.S | K09.86259 | 1.S | 2300 | R-RS-LM1.01
86260 | 1.S | K09.86260 | 1.S | 600 | R-RS-LM1.01
86263 | 1.S | K09.86263 | 1.S | 860 | R-RS-LM1.01
86266 | 1.S | K09.86266 | 1.S | 160 | R-RS-LM1.01
86269 | 1.S | K09.86269 | 1.S | 2200 | R-RS-LM1.01
86272 | 1.S | K09.86272 | 1.S | 190 | R-RS-LM1.01
86277 | 1.S | K09.86277 | 1.S | 1314.51 | R-RS-LM1.01
86285 | 1.NP | K09.86285 | 1.NP | 2300 | R-RS-LM1.01
86286 | 1.NP | K09.86286 | 1.NP | 600 | R-RS-LM1.01
86289 | 1.NP | K09.86289 | 1.NP | 860 | R-RS-LM1.01
86292 | 1.NP | K09.86292 | 1.NP | 160 | R-RS-LM1.01
86295 | 1.NP | K09.86295 | 1.NP | 2200 | R-RS-LM1.01
86298 | 1.NP | K09.86298 | 1.NP | 190 | R-RS-LM1.01
86303 | 1.NP | K09.86303 | 1.NP | 1314.51 | R-RS-LM1.01
86311 | 2.NP | K09.86311 | 2.NP | 2300 | R-RS-LM1.01
86312 | 2.NP | K09.86312 | 2.NP | 600 | R-RS-LM1.01
86315 | 2.NP | K09.86315 | 2.NP | 860 | R-RS-LM1.01
86318 | 2.NP | K09.86318 | 2.NP | 160 | R-RS-LM1.01
86321 | 2.NP | K09.86321 | 2.NP | 2200 | R-RS-LM1.01
86324 | 2.NP | K09.86324 | 2.NP | 190 | R-RS-LM1.01
86329 | 2.NP | K09.86329 | 2.NP | 1314.51 | R-RS-LM1.01
86337 | 3.NP | K09.86337 | 3.NP | 2300 | R-RS-LM1.01
86338 | 3.NP | K09.86338 | 3.NP | 600 | R-RS-LM1.01
86341 | 3.NP | K09.86341 | 3.NP | 860 | R-RS-LM1.01
86344 | 3.NP | K09.86344 | 3.NP | 160 | R-RS-LM1.01
86347 | 3.NP | K09.86347 | 3.NP | 2200 | R-RS-LM1.01
86350 | 3.NP | K09.86350 | 3.NP | 190 | R-RS-LM1.01
86355 | 3.NP | K09.86355 | 3.NP | 1364.51 | R-RS-LM1.01
86363 | 4.NP mezipatro | K09.86363 | 4.NP mezipatro | 400 | R-RS-LM1.01
86374 | 3.NP mezipatro | K09.86374 | 3.NP mezipatro | 440 | R-RS-LM1.01
86380 | 2.NP mezipatro | K09.86380 | 2.NP mezipatro | 440 | R-RS-LM1.01
86386 | 1.NP mezipatro | K09.86386 | 1.NP mezipatro | 440 | R-RS-LM1.01
86392 | 1.S mezipatro | K09.86392 | 1.S mezipatro | 440 | R-RS-LM1.01
86399 | 1.S | K09.86399 | 1.S | 2122 | R-RS-LM1.01
86412 | 1.NP | K09.86412 | 1.NP | 2940 | R-RS-LM1.01
86424 | 2.NP | K09.86424 | 2.NP | 2940.02 | R-RS-LM1.01
86436 | 3.NP | K09.86436 | 3.NP | 2939.98 | R-RS-LM1.01
86448 | 4.NP | K09.86448 | 4.NP | 3490 | R-RS-LM1.01
86489 | 1.S | K09.86489 | 1.S | 106.39 | R-RS-LM1.02
86490 | 1.S | K09.86490 | 1.S | 1409.05 | R-RS-LM1.02
86493 | 1.S | K09.86493 | 1.S | 2383.79 | R-RS-LM1.02
86496 | 1.S | K09.86496 | 1.S | 6896.54 | R-RS-LM1.02
86502 | 1.S | K09.86502 | 1.S | 950 | R-RS-LM1.02
86580 | 1.S | K09.86580 | 1.S | 9.71 | R-RS-LM1.02
86618 | 1.S | K09.86618 | 1.S | 16046.5 | R-RS-LM1.02
86759 | 5.NP | K09.86759 | 5.NP | 3540 | R-RS-LM1.02
87038 | 4.NP | K09.87038 | 4.NP | 427.51 | R-RS-LM1.02
87047 | 4.NP | K09.87047 | 4.NP | 2904.24 | R-RS-LM1.02
87055 | 4.NP | K09.87055 | 4.NP | 2407.51 | R-RS-LM1.02
87068 | 4.NP | K09.87068 | 4.NP | 1910 | R-RS-LM1.02
87076 | 4.NP | K09.87076 | 4.NP | 660 | R-RS-LM1.02
87086 | 4.NP | K09.87086 | 4.NP | 810 | R-RS-LM1.02
87094 | 4.NP | K09.87094 | 4.NP | 150 | R-RS-LM1.02
87104 | 4.NP | K09.87104 | 4.NP | 2220 | R-RS-LM1.02
87112 | 4.NP | K09.87112 | 4.NP | 200 | R-RS-LM1.02
87218 | 4.NP | K09.87218 | 4.NP | 3032.49 | R-RS-LM1.02
87234 | 4.NP | K09.87234 | 4.NP | 1780 | R-RS-LM1.02
87245 | 4.NP | K09.87245 | 4.NP | 605.3 | R-RS-LM1.02
87255 | 4.NP | K09.87255 | 4.NP | 670 | R-RS-LM1.02
87382 | 4.NP | K09.87382 | 4.NP | 220 | R-RS-LM1.02
87392 | 4.NP | K09.87392 | 4.NP | 2180 | R-RS-LM1.02
87400 | 4.NP | K09.87400 | 4.NP | 773.59 | R-RS-LM1.02
87511 | 4.NP | K09.87511 | 4.NP | 1443.99 | R-RS-LM1.02
87512 | 4.NP | K09.87512 | 4.NP | 2110.9 | R-RS-LM1.02
87515 | 4.NP | K09.87515 | 4.NP | 605.3 | R-RS-LM1.02
87518 | 4.NP | K09.87518 | 4.NP | 670 | R-RS-LM1.02
87522 | 4.NP | K09.87522 | 4.NP | 220 | R-RS-LM1.02
87525 | 4.NP | K09.87525 | 4.NP | 2180 | R-RS-LM1.02
87528 | 4.NP | K09.87528 | 4.NP | 222.5 | R-RS-LM1.02
87563 | 4.NP | K09.87563 | 4.NP | 2553.34 | R-RS-LM1.02
87592 | 4.NP | K09.87592 | 4.NP | 2260 | R-RS-LM1.02
87595 | 4.NP | K09.87595 | 4.NP | 660 | R-RS-LM1.02
87598 | 4.NP | K09.87598 | 4.NP | 810 | R-RS-LM1.02
87601 | 4.NP | K09.87601 | 4.NP | 150 | R-RS-LM1.02
87604 | 4.NP | K09.87604 | 4.NP | 2220 | R-RS-LM1.02
87607 | 4.NP | K09.87607 | 4.NP | 200 | R-RS-LM1.02
87610 | 4.NP | K09.87610 | 4.NP | 3040 | R-RS-LM1.02
87644 | 4.NP | K09.87644 | 4.NP | 2534.24 | R-RS-LM1.02
87657 | 4.NP | K09.87657 | 4.NP | 420 | R-RS-LM1.02
87844 | 3.NP mezipatro | K09.87844 | 3.NP mezipatro | 1443.99 | R-RS-LM1.02
87845 | 3.NP mezipatro | K09.87845 | 3.NP mezipatro | 2110.9 | R-RS-LM1.02
87848 | 3.NP mezipatro | K09.87848 | 3.NP mezipatro | 605.3 | R-RS-LM1.02
87851 | 3.NP mezipatro | K09.87851 | 3.NP mezipatro | 670 | R-RS-LM1.02
87854 | 3.NP mezipatro | K09.87854 | 3.NP mezipatro | 220 | R-RS-LM1.02
87857 | 3.NP mezipatro | K09.87857 | 3.NP mezipatro | 2180 | R-RS-LM1.02
87860 | 3.NP mezipatro | K09.87860 | 3.NP mezipatro | 222.5 | R-RS-LM1.02
87863 | 3.NP mezipatro | K09.87863 | 3.NP mezipatro | 2553.34 | R-RS-LM1.02
87997 | 1.S mezipatro | K09.87997 | 1.S mezipatro | 1443.99 | R-RS-LM1.02
87998 | 1.S mezipatro | K09.87998 | 1.S mezipatro | 2110.9 | R-RS-LM1.02
88001 | 1.S mezipatro | K09.88001 | 1.S mezipatro | 605.3 | R-RS-LM1.02
88004 | 1.S mezipatro | K09.88004 | 1.S mezipatro | 670 | R-RS-LM1.02
88007 | 1.S mezipatro | K09.88007 | 1.S mezipatro | 220 | R-RS-LM1.02
88010 | 1.S mezipatro | K09.88010 | 1.S mezipatro | 2180 | R-RS-LM1.02
88013 | 1.S mezipatro | K09.88013 | 1.S mezipatro | 222.5 | R-RS-LM1.02
88016 | 1.S mezipatro | K09.88016 | 1.S mezipatro | 2553.34 | R-RS-LM1.02
88033 | 1.NP mezipatro | K09.88033 | 1.NP mezipatro | 1443.99 | R-RS-LM1.02
88034 | 1.NP mezipatro | K09.88034 | 1.NP mezipatro | 2110.9 | R-RS-LM1.02
88037 | 1.NP mezipatro | K09.88037 | 1.NP mezipatro | 605.3 | R-RS-LM1.02
88040 | 1.NP mezipatro | K09.88040 | 1.NP mezipatro | 670 | R-RS-LM1.02
88043 | 1.NP mezipatro | K09.88043 | 1.NP mezipatro | 220 | R-RS-LM1.02
88046 | 1.NP mezipatro | K09.88046 | 1.NP mezipatro | 2180 | R-RS-LM1.02
88049 | 1.NP mezipatro | K09.88049 | 1.NP mezipatro | 222.5 | R-RS-LM1.02
88052 | 1.NP mezipatro | K09.88052 | 1.NP mezipatro | 2553.34 | R-RS-LM1.02
88069 | 2.NP mezipatro | K09.88069 | 2.NP mezipatro | 1443.99 | R-RS-LM1.02
88070 | 2.NP mezipatro | K09.88070 | 2.NP mezipatro | 2110.9 | R-RS-LM1.02
88073 | 2.NP mezipatro | K09.88073 | 2.NP mezipatro | 605.3 | R-RS-LM1.02
88076 | 2.NP mezipatro | K09.88076 | 2.NP mezipatro | 670 | R-RS-LM1.02
88079 | 2.NP mezipatro | K09.88079 | 2.NP mezipatro | 220 | R-RS-LM1.02
88082 | 2.NP mezipatro | K09.88082 | 2.NP mezipatro | 2180 | R-RS-LM1.02
88085 | 2.NP mezipatro | K09.88085 | 2.NP mezipatro | 222.5 | R-RS-LM1.02
88088 | 2.NP mezipatro | K09.88088 | 2.NP mezipatro | 2553.34 | R-RS-LM1.02
88314 | 1.S | K09.88314 | 1.S | 2260 | R-RS-LM1.02
88317 | 1.S | K09.88317 | 1.S | 660 | R-RS-LM1.02
88320 | 1.S | K09.88320 | 1.S | 810 | R-RS-LM1.02
88323 | 1.S | K09.88323 | 1.S | 150 | R-RS-LM1.02
88326 | 1.S | K09.88326 | 1.S | 2220 | R-RS-LM1.02
88329 | 1.S | K09.88329 | 1.S | 200 | R-RS-LM1.02
88332 | 1.S | K09.88332 | 1.S | 3040 | R-RS-LM1.02
88333 | 1.S | K09.88333 | 1.S | 2534.24 | R-RS-LM1.02
88337 | 1.S | K09.88337 | 1.S | 420 | R-RS-LM1.02
88351 | 1.NP | K09.88351 | 1.NP | 2260 | R-RS-LM1.02
88354 | 1.NP | K09.88354 | 1.NP | 660 | R-RS-LM1.02
88357 | 1.NP | K09.88357 | 1.NP | 810 | R-RS-LM1.02
88360 | 1.NP | K09.88360 | 1.NP | 150 | R-RS-LM1.02
88363 | 1.NP | K09.88363 | 1.NP | 2220 | R-RS-LM1.02
88366 | 1.NP | K09.88366 | 1.NP | 200 | R-RS-LM1.02
88369 | 1.NP | K09.88369 | 1.NP | 3040 | R-RS-LM1.02
88370 | 1.NP | K09.88370 | 1.NP | 2534.24 | R-RS-LM1.02
88374 | 1.NP | K09.88374 | 1.NP | 420 | R-RS-LM1.02
88388 | 2.NP | K09.88388 | 2.NP | 2260 | R-RS-LM1.02
88391 | 2.NP | K09.88391 | 2.NP | 660 | R-RS-LM1.02
88394 | 2.NP | K09.88394 | 2.NP | 810 | R-RS-LM1.02
88397 | 2.NP | K09.88397 | 2.NP | 150 | R-RS-LM1.02
88400 | 2.NP | K09.88400 | 2.NP | 2220 | R-RS-LM1.02
88403 | 2.NP | K09.88403 | 2.NP | 200 | R-RS-LM1.02
88406 | 2.NP | K09.88406 | 2.NP | 3040 | R-RS-LM1.02
88407 | 2.NP | K09.88407 | 2.NP | 2534.24 | R-RS-LM1.02
88411 | 2.NP | K09.88411 | 2.NP | 420 | R-RS-LM1.02
88425 | 3.NP | K09.88425 | 3.NP | 2260 | R-RS-LM1.02
88428 | 3.NP | K09.88428 | 3.NP | 660 | R-RS-LM1.02
88431 | 3.NP | K09.88431 | 3.NP | 810 | R-RS-LM1.02
88434 | 3.NP | K09.88434 | 3.NP | 150 | R-RS-LM1.02
88437 | 3.NP | K09.88437 | 3.NP | 2220 | R-RS-LM1.02
88440 | 3.NP | K09.88440 | 3.NP | 200 | R-RS-LM1.02
88443 | 3.NP | K09.88443 | 3.NP | 3040 | R-RS-LM1.02
88444 | 3.NP | K09.88444 | 3.NP | 2534.24 | R-RS-LM1.02
88448 | 3.NP | K09.88448 | 3.NP | 420 | R-RS-LM1.02
88465 | 1.S | K09.88465 | 1.S | 200 | R-RS-LM1.02
88474 | 1.S mezipatro | K09.88474 | 1.S mezipatro | 1440 | R-RS-LM1.02
88481 | 1.NP | K09.88481 | 1.NP | 1440 | R-RS-LM1.02
88488 | 1.NP mezipatro | K09.88488 | 1.NP mezipatro | 1440 | R-RS-LM1.02
88495 | 2.NP | K09.88495 | 2.NP | 1440 | R-RS-LM1.02
88502 | 2.NP mezipatro | K09.88502 | 2.NP mezipatro | 1440 | R-RS-LM1.02
88509 | 3.NP | K09.88509 | 3.NP | 1440 | R-RS-LM1.02
88516 | 3.NP mezipatro | K09.88516 | 3.NP mezipatro | 1440 | R-RS-LM1.02
88523 | 4.NP | K09.88523 | 4.NP | 1440 | R-RS-LM1.02
88530 | 4.NP mezipatro | K09.88530 | 4.NP mezipatro | 1440 | R-RS-LM1.02
89320 | 4.NP | K09.89320 | 4.NP | 684.914 | R-RS-LM4.14
89329 | 4.NP | K09.89329 | 4.NP | 120 | R-RS-LM4.14
89332 | 4.NP | K09.89332 | 4.NP | 599.56 | R-RS-LM4.14
89838 | 1.S | K09.89838 | 1.S | 151.39 | R-RS-LM1.14
89839 | 1.S | K09.89839 | 1.S | 1364.05 | R-RS-LM1.14
89842 | 1.S | K09.89842 | 1.S | 2308.79 | R-RS-LM1.14
89845 | 1.S | K09.89845 | 1.S | 7043.03 | R-RS-LM1.14
89848 | 1.S | K09.89848 | 1.S | 16096.5 | R-RS-LM1.14
89849 | 1.NP | K09.89849 | 1.NP | 2960 | R-RS-LM1.14
89850 | 1.S | K09.89850 | 1.S | 890 | R-RS-LM1.14
89853 | 1.NP | K09.89853 | 1.NP | 4075.56 | R-RS-LM1.14
89854 | 1.NP | K09.89854 | 1.NP | 8672.42 | R-RS-LM1.14
89855 | 1.NP | K09.89855 | 1.NP | 12174.1 | R-RS-LM1.14
89856 | 1.NP | K09.89856 | 1.NP | 5812.84 | R-RS-LM1.14
89860 | 1.NP | K09.89860 | 1.NP | 2332.86 | R-RS-LM1.14
89862 | 1.NP | K09.89862 | 1.NP | 3784.4 | R-RS-LM1.14
89863 | 1.NP | K09.89863 | 1.NP | 3784.4 | R-RS-LM1.14
89865 | 1.NP | K09.89865 | 1.NP | 3784.4 | R-RS-LM1.14
89867 | 1.NP | K09.89867 | 1.NP | 120 | R-RS-LM1.14
89869 | 1.NP | K09.89869 | 1.NP | 3737.19 | R-RS-LM1.14
89873 | 1.NP | K09.89873 | 1.NP | 1393.85 | R-RS-LM1.14
89874 | 1.NP | K09.89874 | 1.NP | 6247.19 | R-RS-LM1.14
89876 | 1.NP | K09.89876 | 1.NP | 120 | R-RS-LM1.14
89878 | 1.NP | K09.89878 | 1.NP | 748.89 | R-RS-LM1.14
89882 | 1.NP | K09.89882 | 1.NP | 1128.6 | R-RS-LM1.14
89883 | 1.NP | K09.89883 | 1.NP | 140.72 | R-RS-LM1.14
89884 | 1.NP | K09.89884 | 1.NP | 241.42 | R-RS-LM1.14
89900 | 1.NP | K09.89900 | 1.NP | 120 | R-RS-LM1.14
89902 | 1.NP | K09.89902 | 1.NP | 6966.73 | R-RS-LM1.14
89906 | 1.NP | K09.89906 | 1.NP | 94.82 | R-RS-LM1.14
89909 | 1.NP | K09.89909 | 1.NP | 100 | R-RS-LM1.14
89912 | 1.NP | K09.89912 | 1.NP | 4755.56 | R-RS-LM1.14
89915 | 1.NP | K09.89915 | 1.NP | 123.27 | R-RS-LM1.14
89918 | 1.NP | K09.89918 | 1.NP | 2075.2 | R-RS-LM1.14
89921 | 1.NP | K09.89921 | 1.NP | 79.67 | R-RS-LM1.14
89927 | 1.NP | K09.89927 | 1.NP | 1800 | R-RS-LM1.14
89930 | 1.NP | K09.89930 | 1.NP | 354.56 | R-RS-LM1.14
89933 | 1.NP | K09.89933 | 1.NP | 5094.56 | R-RS-LM1.14
89936 | 1.NP | K09.89936 | 1.NP | 1563.16 | R-RS-LM1.14
89938 | 1.NP | K09.89938 | 1.NP | 1919.29 | R-RS-LM1.14
89941 | 1.NP | K09.89941 | 1.NP | 59.3 | R-RS-LM1.14
89944 | 1.NP | K09.89944 | 1.NP | 4172.5 | R-RS-LM1.14
89947 | 1.NP | K09.89947 | 1.NP | 605.48 | R-RS-LM1.14
89949 | 1.NP | K09.89949 | 1.NP | 2469.94 | R-RS-LM1.14
89951 | 1.NP | K09.89951 | 1.NP | 2086.16 | R-RS-LM1.14
89952 | 1.NP | K09.89952 | 1.NP | 335.48 | R-RS-LM1.14
89955 | 1.NP | K09.89955 | 1.NP | 31.12 | R-RS-LM1.14
89958 | 1.NP | K09.89958 | 1.NP | 400.46 | R-RS-LM1.14
89961 | 1.NP | K09.89961 | 1.NP | 2217.28 | R-RS-LM1.14
89964 | 1.NP | K09.89964 | 1.NP | 5285.33 | R-RS-LM1.14
89967 | 1.NP | K09.89967 | 1.NP | 2709.78 | R-RS-LM1.14
89968 | 1.NP | K09.89968 | 1.NP | 120 | R-RS-LM1.14
89970 | 1.NP | K09.89970 | 1.NP | 4021.11 | R-RS-LM1.14
89972 | 1.NP | K09.89972 | 1.NP | 3188.48 | R-RS-LM1.14
89977 | 1.NP | K09.89977 | 1.NP | 856.35 | R-RS-LM1.14
89978 | 1.NP | K09.89978 | 1.NP | 522.081 | R-RS-LM1.14
89979 | 1.NP | K09.89979 | 1.NP | 4503.96 | R-RS-LM1.14
89981 | 1.NP | K09.89981 | 1.NP | 770.51 | R-RS-LM1.14
89985 | 1.NP | K09.89985 | 1.NP | 113.21 | R-RS-LM1.14
89986 | 1.NP | K09.89986 | 1.NP | 4970 | R-RS-LM1.14
89989 | 1.NP | K09.89989 | 1.NP | 930 | R-RS-LM1.14
90000 | 1.NP | K09.90000 | 1.NP | 537.51 | R-RS-LM1.14
90001 | 1.NP | K09.90001 | 1.NP | 241.42 | R-RS-LM1.14
90012 | 1.NP | K09.90012 | 1.NP | 1023.99 | R-RS-LM1.14
90013 | 1.NP | K09.90013 | 1.NP | 120 | R-RS-LM1.14
90015 | 1.NP | K09.90015 | 1.NP | 639.79 | R-RS-LM1.14
90413 | 1.NP | K09.90413 | 1.NP | 3784.4 | R-RS-LM1.14
90429 | 1.NP | K09.90429 | 1.NP | 1749.45 | R-RS-LM1.14
90430 | 1.NP | K09.90430 | 1.NP | 241.42 | R-RS-LM1.14
90446 | 1.NP | K09.90446 | 1.NP | 91.27 | R-RS-LM1.14
90456 | 1.NP | K09.90456 | 1.NP | 71.12 | R-RS-LM1.14
90466 | 1.NP | K09.90466 | 1.NP | 5150 | R-RS-LM1.14
90561 | 1.NP | K09.90561 | 1.NP | 120 | R-RS-LM1.14
90564 | 1.NP | K09.90564 | 1.NP | 7404.67 | R-RS-LM1.14
90650 | 1.S | K09.90650 | 1.S | 151.39 | R-RS-LM2.14
90651 | 1.S | K09.90651 | 1.S | 1364.05 | R-RS-LM2.14
90654 | 1.S | K09.90654 | 1.S | 2308.79 | R-RS-LM2.14
90657 | 1.S | K09.90657 | 1.S | 7088.13 | R-RS-LM2.14
90660 | 1.S | K09.90660 | 1.S | 16076.5 | R-RS-LM2.14
90661 | 2.NP | K09.90661 | 2.NP | 5940 | R-RS-LM2.14
90662 | 1.S | K09.90662 | 1.S | 910 | R-RS-LM2.14
90665 | 2.NP | K09.90665 | 2.NP | 4066.48 | R-RS-LM2.14
90666 | 2.NP | K09.90666 | 2.NP | 706.962 | R-RS-LM2.14
90667 | 2.NP | K09.90667 | 2.NP | 12180.7 | R-RS-LM2.14
90672 | 2.NP | K09.90672 | 2.NP | 2335.36 | R-RS-LM2.14
90674 | 2.NP | K09.90674 | 2.NP | 3801.9 | R-RS-LM2.14
90675 | 2.NP | K09.90675 | 2.NP | 3801.9 | R-RS-LM2.14
90677 | 2.NP | K09.90677 | 2.NP | 3959.39 | R-RS-LM2.14
90679 | 2.NP | K09.90679 | 2.NP | 120 | R-RS-LM2.14
90681 | 2.NP | K09.90681 | 2.NP | 3752.19 | R-RS-LM2.14
90685 | 2.NP | K09.90685 | 2.NP | 935.84 | R-RS-LM2.14
90686 | 2.NP | K09.90686 | 2.NP | 6264.69 | R-RS-LM2.14
90694 | 2.NP | K09.90694 | 2.NP | 988.6 | R-RS-LM2.14
90703 | 2.NP | K09.90703 | 2.NP | 120 | R-RS-LM2.14
90705 | 2.NP | K09.90705 | 2.NP | 6930.45 | R-RS-LM2.14
90709 | 2.NP | K09.90709 | 2.NP | 1109.77 | R-RS-LM2.14
90712 | 2.NP | K09.90712 | 2.NP | 2100 | R-RS-LM2.14
90715 | 2.NP | K09.90715 | 2.NP | 4755.56 | R-RS-LM2.14
90718 | 2.NP | K09.90718 | 2.NP | 159.55 | R-RS-LM2.14
90721 | 2.NP | K09.90721 | 2.NP | 1875.2 | R-RS-LM2.14
90724 | 2.NP | K09.90724 | 2.NP | 1081.88 | R-RS-LM2.14
90725 | 2.NP | K09.90725 | 2.NP | 1972.52 | R-RS-LM2.14
90728 | 2.NP | K09.90728 | 2.NP | 1800 | R-RS-LM2.14
90731 | 2.NP | K09.90731 | 2.NP | 354.56 | R-RS-LM2.14
90734 | 2.NP | K09.90734 | 2.NP | 5094.56 | R-RS-LM2.14
90738 | 2.NP | K09.90738 | 2.NP | 1919.29 | R-RS-LM2.14
90741 | 2.NP | K09.90741 | 2.NP | 134.943 | R-RS-LM2.14
90744 | 2.NP | K09.90744 | 2.NP | 4172.5 | R-RS-LM2.14
90747 | 2.NP | K09.90747 | 2.NP | 647.978 | R-RS-LM2.14
90749 | 2.NP | K09.90749 | 2.NP | 2852.31 | R-RS-LM2.14
90751 | 2.NP | K09.90751 | 2.NP | 2071.93 | R-RS-LM2.14
90752 | 2.NP | K09.90752 | 2.NP | 195.48 | R-RS-LM2.14
90755 | 2.NP | K09.90755 | 2.NP | 45.35 | R-RS-LM2.14
90758 | 2.NP | K09.90758 | 2.NP | 280.46 | R-RS-LM2.14
90761 | 2.NP | K09.90761 | 2.NP | 2217.28 | R-RS-LM2.14
90764 | 2.NP | K09.90764 | 2.NP | 5225.33 | R-RS-LM2.14
90767 | 2.NP | K09.90767 | 2.NP | 3092.16 | R-RS-LM2.14
90768 | 2.NP | K09.90768 | 2.NP | 120 | R-RS-LM2.14
90770 | 2.NP | K09.90770 | 2.NP | 4018.61 | R-RS-LM2.14
90772 | 2.NP | K09.90772 | 2.NP | 3168.48 | R-RS-LM2.14
90777 | 2.NP | K09.90777 | 2.NP | 578.89 | R-RS-LM2.14
90778 | 2.NP | K09.90778 | 2.NP | 522.081 | R-RS-LM2.14
90779 | 2.NP | K09.90779 | 2.NP | 4093.24 | R-RS-LM2.14
90781 | 2.NP | K09.90781 | 2.NP | 1181.23 | R-RS-LM2.14
90785 | 2.NP | K09.90785 | 2.NP | 113.21 | R-RS-LM2.14
90786 | 2.NP | K09.90786 | 2.NP | 4950 | R-RS-LM2.14
90789 | 2.NP | K09.90789 | 2.NP | 1340.72 | R-RS-LM2.14
90800 | 2.NP | K09.90800 | 2.NP | 537.51 | R-RS-LM2.14
90801 | 2.NP | K09.90801 | 2.NP | 241.42 | R-RS-LM2.14
90812 | 2.NP | K09.90812 | 2.NP | 1066.59 | R-RS-LM2.14
90813 | 2.NP | K09.90813 | 2.NP | 120 | R-RS-LM2.14
90815 | 2.NP | K09.90815 | 2.NP | 628.87 | R-RS-LM2.14
90851 | 2.NP | K09.90851 | 2.NP | 4508.44 | R-RS-LM2.14
91182 | 2.NP | K09.91182 | 2.NP | 320 | R-RS-LM2.14
91193 | 2.NP | K09.91193 | 2.NP | 142.37 | R-RS-LM2.14
91212 | 2.NP | K09.91212 | 2.NP | 120.72 | R-RS-LM2.14
91213 | 2.NP | K09.91213 | 2.NP | 241.42 | R-RS-LM2.14
91315 | 2.NP | K09.91315 | 2.NP | 1450 | R-RS-LM2.14
91323 | 2.NP | K09.91323 | 2.NP | 280 | R-RS-LM2.14
91332 | 2.NP | K09.91332 | 2.NP | 140.63 | R-RS-LM2.14
91346 | 2.NP | K09.91346 | 2.NP | 120 | R-RS-LM2.14
91349 | 2.NP | K09.91349 | 2.NP | 8314.34 | R-RS-LM2.14
91442 | 2.NP | K09.91442 | 2.NP | 2682.59 | R-RS-LM2.14
91443 | 2.NP | K09.91443 | 2.NP | 241.42 | R-RS-LM2.14
92066 | 1.S | K09.92066 | 1.S | 151.39 | R-RS-LM3.14
92067 | 1.S | K09.92067 | 1.S | 1379.05 | R-RS-LM3.14
92070 | 1.S | K09.92070 | 1.S | 2293.79 | R-RS-LM3.14
92073 | 1.S | K09.92073 | 1.S | 6901.53 | R-RS-LM3.14
92076 | 1.S | K09.92076 | 1.S | 16041.5 | R-RS-LM3.14
92077 | 3.NP | K09.92077 | 3.NP | 8920 | R-RS-LM3.14
92078 | 1.S | K09.92078 | 1.S | 930 | R-RS-LM3.14
92081 | 3.NP | K09.92081 | 3.NP | 4011.33 | R-RS-LM3.14
92082 | 3.NP | K09.92082 | 3.NP | 706.962 | R-RS-LM3.14
92083 | 3.NP | K09.92083 | 3.NP | 12214.1 | R-RS-LM3.14
92087 | 3.NP | K09.92087 | 3.NP | 2320.36 | R-RS-LM3.14
92088 | 3.NP | K09.92088 | 3.NP | 3800.1 | R-RS-LM3.14
92089 | 3.NP | K09.92089 | 3.NP | 3800.1 | R-RS-LM3.14
92091 | 3.NP | K09.92091 | 3.NP | 3800.1 | R-RS-LM3.14
92095 | 3.NP | K09.92095 | 3.NP | 7458.04 | R-RS-LM3.14
92099 | 3.NP | K09.92099 | 3.NP | 562.69 | R-RS-LM3.14
92108 | 3.NP | K09.92108 | 3.NP | 1109.77 | R-RS-LM3.14
92111 | 3.NP | K09.92111 | 3.NP | 1942.52 | R-RS-LM3.14
92114 | 3.NP | K09.92114 | 3.NP | 4755.56 | R-RS-LM3.14
92117 | 3.NP | K09.92117 | 3.NP | 200.54 | R-RS-LM3.14
92120 | 3.NP | K09.92120 | 3.NP | 1875.2 | R-RS-LM3.14
92123 | 3.NP | K09.92123 | 3.NP | 1066.47 | R-RS-LM3.14
92124 | 3.NP | K09.92124 | 3.NP | 1972.52 | R-RS-LM3.14
92130 | 3.NP | K09.92130 | 3.NP | 1185.79 | R-RS-LM3.14
92133 | 3.NP | K09.92133 | 3.NP | 5135 | R-RS-LM3.14
92136 | 3.NP | K09.92136 | 3.NP | 1919.29 | R-RS-LM3.14
92139 | 3.NP | K09.92139 | 3.NP | 493.094 | R-RS-LM3.14
92142 | 3.NP | K09.92142 | 3.NP | 4930 | R-RS-LM3.14
92145 | 3.NP | K09.92145 | 3.NP | 632.978 | R-RS-LM3.14
92147 | 3.NP | K09.92147 | 3.NP | 2962.24 | R-RS-LM3.14
92149 | 3.NP | K09.92149 | 3.NP | 1337 | R-RS-LM3.14
92150 | 3.NP | K09.92150 | 3.NP | 355.48 | R-RS-LM3.14
92153 | 3.NP | K09.92153 | 3.NP | 245.35 | R-RS-LM3.14
92156 | 3.NP | K09.92156 | 3.NP | 440.46 | R-RS-LM3.14
92159 | 3.NP | K09.92159 | 3.NP | 1942.21 | R-RS-LM3.14
92162 | 3.NP | K09.92162 | 3.NP | 5225.33 | R-RS-LM3.14
92165 | 3.NP | K09.92165 | 3.NP | 3107.16 | R-RS-LM3.14
92166 | 3.NP | K09.92166 | 3.NP | 120 | R-RS-LM3.14
92168 | 3.NP | K09.92168 | 3.NP | 4033.61 | R-RS-LM3.14
92170 | 3.NP | K09.92170 | 3.NP | 3337.32 | R-RS-LM3.14
92175 | 3.NP | K09.92175 | 3.NP | 576.35 | R-RS-LM3.14
92176 | 3.NP | K09.92176 | 3.NP | 522.081 | R-RS-LM3.14
92177 | 3.NP | K09.92177 | 3.NP | 3873.51 | R-RS-LM3.14
92179 | 3.NP | K09.92179 | 3.NP | 1400.96 | R-RS-LM3.14
92183 | 3.NP | K09.92183 | 3.NP | 113.21 | R-RS-LM3.14
92184 | 3.NP | K09.92184 | 3.NP | 5118.84 | R-RS-LM3.14
92187 | 3.NP | K09.92187 | 3.NP | 1560.45 | R-RS-LM3.14
92196 | 3.NP | K09.92196 | 3.NP | 537.51 | R-RS-LM3.14
92197 | 3.NP | K09.92197 | 3.NP | 241.42 | R-RS-LM3.14
92208 | 3.NP | K09.92208 | 3.NP | 6250.67 | R-RS-LM3.14
92244 | 3.NP | K09.92244 | 3.NP | 1450 | R-RS-LM3.14
92245 | 3.NP | K09.92245 | 3.NP | 280 | R-RS-LM3.14
92248 | 3.NP | K09.92248 | 3.NP | 155.63 | R-RS-LM3.14
92249 | 3.NP | K09.92249 | 3.NP | 120 | R-RS-LM3.14
92251 | 3.NP | K09.92251 | 3.NP | 11036.9 | R-RS-LM3.14
92468 | 1.S | K09.92468 | 1.S | 1458.48 | R-RS-LM0.06
92469 | 1.S | K09.92469 | 1.S | 1258.13 | R-RS-LM0.06
92470 | 1.S | K09.92470 | 1.S | 109.65 | R-RS-LM0.06
92477 | 1.S | K09.92477 | 1.S | 3508.02 | R-RS-LM0.06
92512 | 1.S | K09.92512 | 1.S | 4114.13 | R-RS-LM0.07
92513 | 1.S | K09.92513 | 1.S | 6802.03 | R-RS-LM0.07
92514 | 1.S | K09.92514 | 1.S | 2206.57 | R-RS-LM0.07
92515 | 1.S | K09.92515 | 1.S | 1283.05 | R-RS-LM0.07
92518 | 1.S | K09.92518 | 1.S | 1178.41 | R-RS-LM0.07
92519 | 1.S | K09.92519 | 1.S | 103.019 | R-RS-LM0.07
92524 | 1.S | K09.92524 | 1.S | 9877.5 | R-RS-LM0.07
92529 | 1.S | K09.92529 | 1.S | 44.6 | R-RS-LM0.07
92530 | 1.S | K09.92530 | 1.S | 495.98 | R-RS-LM0.07
92575 | 1.S | K09.92575 | 1.S | 1415.73 | R-RS-LM0.07
92579 | 1.S | K09.92579 | 1.S | 178.64 | R-RS-LM0.07
92583 | 1.S | K09.92583 | 1.S | 1800 | R-RS-LM0.07
92587 | 1.S | K09.92587 | 1.S | 2684.66 | R-RS-LM0.07
92591 | 1.S | K09.92591 | 1.S | 1850 | R-RS-LM0.07
92606 | 1.S | K09.92606 | 1.S | 399.52 | R-RS-LM0.08/A
92607 | 1.S | K09.92607 | 1.S | 6832.03 | R-RS-LM0.08/A
92608 | 1.S | K09.92608 | 1.S | 2236.57 | R-RS-LM0.08/A
92609 | 1.S | K09.92609 | 1.S | 1298.05 | R-RS-LM0.08/A
92612 | 1.S | K09.92612 | 1.S | 1178.41 | R-RS-LM0.08/A
92618 | 1.S | K09.92618 | 1.S | 13722.7 | R-RS-LM0.08/A
92677 | 1.S | K09.92677 | 1.S | 1842.89 | R-RS-LM0.08/B
92678 | 1.S | K09.92678 | 1.S | 6892.03 | R-RS-LM0.08/B
92679 | 1.S | K09.92679 | 1.S | 2296.57 | R-RS-LM0.08/B
92680 | 1.S | K09.92680 | 1.S | 1328.05 | R-RS-LM0.08/B
92683 | 1.S | K09.92683 | 1.S | 1178.41 | R-RS-LM0.08/B
92684 | 1.S | K09.92684 | 1.S | 58.019 | R-RS-LM0.08/B
92689 | 1.S | K09.92689 | 1.S | 15307.5 | R-RS-LM0.08/B
92740 | 1.S mezipatro | K09.92740 | 1.S mezipatro | 668.84 | R-RS-LM0.08/B
92743 | 1.S mezipatro | K09.92743 | 1.S mezipatro | 220.031 | R-RS-LM0.08/B
92748 | 1.S mezipatro | K09.92748 | 1.S mezipatro | 2422.06 | R-RS-LM0.08/B
