Properties of the parts of a building model (IFC4), part 6 of 7

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x1,5 (1792)
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x1,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
92752 | 1.S mezipatro | K09.92752 | 1.S mezipatro | 127.78 | R-RS-LM0.08/B
92762 | 1.S | K09.92762 | 1.S | 6922.03 | R-RS-LM0.08/C
92763 | 1.S | K09.92763 | 1.S | 2326.57 | R-RS-LM0.08/C
92764 | 1.S | K09.92764 | 1.S | 1343.05 | R-RS-LM0.08/C
92767 | 1.S | K09.92767 | 1.S | 879.32 | R-RS-LM0.08/C
92773 | 1.S | K09.92773 | 1.S | 17695.6 | R-RS-LM0.08/C
92829 | 1.S mezipatro | K09.92829 | 1.S mezipatro | 10.89 | R-RS-LM0.08/C
92837 | 1.S | K09.92837 | 1.S | 7309.22 | R-RS-LM0.09
92838 | 1.S | K09.92838 | 1.S | 6862.03 | R-RS-LM0.09
92839 | 1.S | K09.92839 | 1.S | 2266.57 | R-RS-LM0.09
92840 | 1.S | K09.92840 | 1.S | 1313.05 | R-RS-LM0.09
92843 | 1.S | K09.92843 | 1.S | 959.71 | R-RS-LM0.09
92844 | 1.S | K09.92844 | 1.S | 77.934 | R-RS-LM0.09
92849 | 1.S | K09.92849 | 1.S | 12389.6 | R-RS-LM0.09
93094 | 1.S | K09.93094 | 1.S | 151.39 | R-RS-LM5.14
93095 | 1.S | K09.93095 | 1.S | 1379.05 | R-RS-LM5.14
93098 | 1.S | K09.93098 | 1.S | 2323.79 | R-RS-LM5.14
93101 | 1.S | K09.93101 | 1.S | 6926.54 | R-RS-LM5.14
93102 | 1.S | K09.93102 | 1.S | 950 | R-RS-LM5.14
93105 | 1.S | K09.93105 | 1.S | 16031.5 | R-RS-LM5.14
93114 | 5.NP | K09.93114 | 5.NP | 16900 | R-RS-LM5.14
93206 | 5.NP | K09.93206 | 5.NP | 713.7 | R-RS-LM5.14
93209 | 5.NP | K09.93209 | 5.NP | 17887.3 | R-RS-LM5.14
93213 | 5.NP | K09.93213 | 5.NP | 3326.3 | R-RS-LM5.14
93227 | 5.NP | K09.93227 | 5.NP | 300.037 | R-RS-LM5.14
93234 | 5.NP | K09.93234 | 5.NP | 180 | R-RS-LM5.14
93239 | 5.NP | K09.93239 | 5.NP | 1960 | R-RS-LM5.14
93243 | 5.NP | K09.93243 | 5.NP | 1400 | R-RS-LM5.14
93247 | 5.NP | K09.93247 | 5.NP | 1720 | R-RS-LM5.14
93251 | 5.NP | K09.93251 | 5.NP | 2140 | R-RS-LM5.14
93255 | 5.NP | K09.93255 | 5.NP | 150 | R-RS-LM5.14
93259 | 5.NP | K09.93259 | 5.NP | 4866.3 | R-RS-LM5.14
93262 | 5.NP | K09.93262 | 5.NP | 320.037 | R-RS-LM5.14
93265 | 5.NP | K09.93265 | 5.NP | 12822.9 | R-RS-LM5.14
93271 | 5.NP | K09.93271 | 5.NP | 2880 | R-RS-LM5.14
93275 | 5.NP | K09.93275 | 5.NP | 160 | R-RS-LM5.14
93279 | 5.NP | K09.93279 | 5.NP | 4500 | R-RS-LM5.14
93283 | 5.NP | K09.93283 | 5.NP | 3320 | R-RS-LM5.14
93287 | 5.NP | K09.93287 | 5.NP | 4550 | R-RS-LM5.14
93297 | 1.S | K09.93297 | 1.S | 151.39 | R-RS-LM5.15
93298 | 1.S | K09.93298 | 1.S | 1379.05 | R-RS-LM5.15
93301 | 1.S | K09.93301 | 1.S | 2323.79 | R-RS-LM5.15
93304 | 1.S | K09.93304 | 1.S | 6896.54 | R-RS-LM5.15
93305 | 1.S | K09.93305 | 1.S | 950 | R-RS-LM5.15
93308 | 1.S | K09.93308 | 1.S | 16031.5 | R-RS-LM5.15
93315 | 5.NP | K09.93315 | 5.NP | 17153.5 | R-RS-LM5.15
93500 | 5.NP | K09.93500 | 5.NP | 3316.3 | R-RS-LM5.15
93535 | 5.NP | K09.93535 | 5.NP | 4884.24 | R-RS-LM5.15
93549 | 5.NP | K09.93549 | 5.NP | 155 | R-RS-LM5.15
93561 | 5.NP | K09.93561 | 5.NP | 3730 | R-RS-LM5.15
93569 | 5.NP | K09.93569 | 5.NP | 1635 | R-RS-LM5.15
93627 | 5.NP | K09.93627 | 5.NP | 763.7 | R-RS-LM5.15
93643 | 5.NP | K09.93643 | 5.NP | 11041.1 | R-RS-LM5.15
93731 | 5.NP | K09.93731 | 5.NP | 300 | R-RS-LM5.15
93757 | 5.NP | K09.93757 | 5.NP | 5096.3 | R-RS-LM5.15
93765 | 5.NP | K09.93765 | 5.NP | 1520 | R-RS-LM5.15
93773 | 5.NP | K09.93773 | 5.NP | 3390 | R-RS-LM5.15
93863 | 5.NP | K09.93863 | 5.NP | 812.47 | R-RS-LM5.15
93876 | 5.NP | K09.93876 | 5.NP | 122.019 | R-RS-LM5.15
94850 | 1.S | K09.94850 | 1.S | 151.39 | R-RS-LM5.04
94851 | 1.S | K09.94851 | 1.S | 1379.05 | R-RS-LM5.04
94854 | 1.S | K09.94854 | 1.S | 2323.79 | R-RS-LM5.04
94857 | 1.S | K09.94857 | 1.S | 6851.54 | R-RS-LM5.04
94858 | 1.S | K09.94858 | 1.S | 950 | R-RS-LM5.04
94861 | 1.S | K09.94861 | 1.S | 16031.5 | R-RS-LM5.04
94868 | 5.NP | K09.94868 | 5.NP | 16920 | R-RS-LM5.04
94979 | 5.NP | K09.94979 | 5.NP | 119.963 | R-RS-LM5.04
94987 | 5.NP | K09.94987 | 5.NP | 189.19 | R-RS-LM5.04
94989 | 5.NP | K09.94989 | 5.NP | 1795 | R-RS-LM5.04
94994 | 5.NP | K09.94994 | 5.NP | 737.44 | R-RS-LM5.04
95000 | 5.NP | K09.95000 | 5.NP | 272.75 | R-RS-LM5.04
95004 | 5.NP | K09.95004 | 5.NP | 850 | R-RS-LM5.04
95008 | 5.NP | K09.95008 | 5.NP | 4168.94 | R-RS-LM5.04
95029 | 5.NP | K09.95029 | 5.NP | 320 | R-RS-LM5.04
95032 | 5.NP | K09.95032 | 5.NP | 1407.59 | R-RS-LM5.04
95039 | 5.NP | K09.95039 | 5.NP | 5172.41 | R-RS-LM5.04
95042 | 5.NP | K09.95042 | 5.NP | 280 | R-RS-LM5.04
95047 | 5.NP | K09.95047 | 5.NP | 579.7 | R-RS-LM5.04
95051 | 5.NP | K09.95051 | 5.NP | 1260 | R-RS-LM5.04
95055 | 5.NP | K09.95055 | 5.NP | 179.42 | R-RS-LM5.04
95059 | 5.NP | K09.95059 | 5.NP | 3240 | R-RS-LM5.04
95063 | 5.NP | K09.95063 | 5.NP | 1057.42 | R-RS-LM5.04
95067 | 5.NP | K09.95067 | 5.NP | 1933.91 | R-RS-LM5.04
95071 | 5.NP | K09.95071 | 5.NP | 4071.7 | R-RS-LM5.04
95075 | 5.NP | K09.95075 | 5.NP | 226.089 | R-RS-LM5.04
95079 | 5.NP | K09.95079 | 5.NP | 1700 | R-RS-LM5.04
95083 | 5.NP | K09.95083 | 5.NP | 1200 | R-RS-LM5.04
95087 | 5.NP | K09.95087 | 5.NP | 1800 | R-RS-LM5.04
95091 | 5.NP | K09.95091 | 5.NP | 3250 | R-RS-LM5.04
95799 | 1.S | K09.95799 | 1.S | 151.39 | R-RS-LM5.13
95800 | 1.S | K09.95800 | 1.S | 1379.05 | R-RS-LM5.13
95803 | 1.S | K09.95803 | 1.S | 2323.79 | R-RS-LM5.13
95806 | 1.S | K09.95806 | 1.S | 6941.54 | R-RS-LM5.13
95807 | 1.S | K09.95807 | 1.S | 950 | R-RS-LM5.13
95810 | 1.S | K09.95810 | 1.S | 16031.5 | R-RS-LM5.13
95815 | 5.NP | K09.95815 | 5.NP | 16900 | R-RS-LM5.13
95825 | 5.NP | K09.95825 | 5.NP | 698.74 | R-RS-LM5.13
96050 | 5.NP | K09.96050 | 5.NP | 4749.71 | R-RS-LM5.13
96053 | 5.NP | K09.96053 | 5.NP | 5044.97 | R-RS-LM5.13
96056 | 5.NP | K09.96056 | 5.NP | 1184.15 | R-RS-LM5.13
96061 | 5.NP | K09.96061 | 5.NP | 2300 | R-RS-LM5.13
96065 | 5.NP | K09.96065 | 5.NP | 215.85 | R-RS-LM5.13
96069 | 5.NP | K09.96069 | 5.NP | 3350 | R-RS-LM5.13
96073 | 5.NP | K09.96073 | 5.NP | 320.029 | R-RS-LM5.13
96076 | 5.NP | K09.96076 | 5.NP | 11926.8 | R-RS-LM5.13
96083 | 5.NP | K09.96083 | 5.NP | 5044.97 | R-RS-LM5.13
96086 | 5.NP | K09.96086 | 5.NP | 320.029 | R-RS-LM5.13
96089 | 5.NP | K09.96089 | 5.NP | 5240 | R-RS-LM5.13
96094 | 5.NP | K09.96094 | 5.NP | 2200 | R-RS-LM5.13
96098 | 5.NP | K09.96098 | 5.NP | 940 | R-RS-LM5.13
96102 | 5.NP | K09.96102 | 5.NP | 4650 | R-RS-LM5.13
96106 | 5.NP | K09.96106 | 5.NP | 1466.03 | R-RS-LM5.13
96109 | 5.NP | K09.96109 | 5.NP | 161.42 | R-RS-LM5.13
96114 | 5.NP | K09.96114 | 5.NP | 3229.53 | R-RS-LM5.13
96118 | 5.NP | K09.96118 | 5.NP | 1660 | R-RS-LM5.13
96122 | 5.NP | K09.96122 | 5.NP | 190.47 | R-RS-LM5.13
96126 | 5.NP | K09.96126 | 5.NP | 3450 | R-RS-LM5.13
96133 | 5.NP | K09.96133 | 5.NP | 5333.97 | R-RS-LM5.13
96138 | 5.NP | K09.96138 | 5.NP | 265 | R-RS-LM5.13
96142 | 5.NP | K09.96142 | 5.NP | 4400 | R-RS-LM5.13
96146 | 5.NP | K09.96146 | 5.NP | 1655 | R-RS-LM5.13
96150 | 5.NP | K09.96150 | 5.NP | 5181 | R-RS-LM5.13
96154 | 5.NP | K09.96154 | 5.NP | 3470 | R-RS-LM5.13
96158 | 5.NP | K09.96158 | 5.NP | 320.029 | R-RS-LM5.13
96161 | 5.NP | K09.96161 | 5.NP | 8473.45 | R-RS-LM5.13
96168 | 5.NP | K09.96168 | 5.NP | 320.029 | R-RS-LM5.13
96171 | 5.NP | K09.96171 | 5.NP | 18.58 | R-RS-LM5.13
96178 | 5.NP | K09.96178 | 5.NP | 2781.3 | R-RS-LM5.13
96181 | 5.NP | K09.96181 | 5.NP | 300 | R-RS-LM5.13
96186 | 5.NP | K09.96186 | 5.NP | 1250 | R-RS-LM5.13
96190 | 5.NP | K09.96190 | 5.NP | 300.029 | R-RS-LM5.13
96253 | 1.S | K09.96253 | 1.S | 151.39 | R-RS-LM5.03
96254 | 1.S | K09.96254 | 1.S | 1379.05 | R-RS-LM5.03
96257 | 1.S | K09.96257 | 1.S | 2323.79 | R-RS-LM5.03
96260 | 1.S | K09.96260 | 1.S | 6911.54 | R-RS-LM5.03
96261 | 1.S | K09.96261 | 1.S | 950 | R-RS-LM5.03
96264 | 1.S | K09.96264 | 1.S | 16031.5 | R-RS-LM5.03
96269 | 5.NP | K09.96269 | 5.NP | 16900 | R-RS-LM5.03
96270 | 5.NP | K09.96270 | 5.NP | 728.7 | R-RS-LM5.03
96280 | 5.NP | K09.96280 | 5.NP | 17148.9 | R-RS-LM5.03
96459 | 5.NP | K09.96459 | 5.NP | 5091.3 | R-RS-LM5.03
96480 | 5.NP | K09.96480 | 5.NP | 299.99 | R-RS-LM5.03
96514 | 5.NP | K09.96514 | 5.NP | 2240 | R-RS-LM5.03
96526 | 5.NP | K09.96526 | 5.NP | 2180 | R-RS-LM5.03
96536 | 5.NP | K09.96536 | 5.NP | 4530 | R-RS-LM5.03
96612 | 1.S | K09.96612 | 1.S | 1321.05 | R-RS-LM0.01
96615 | 1.S | K09.96615 | 1.S | 2320 | R-RS-LM0.01
96620 | 1.S | K09.96620 | 1.S | 4557.86 | R-RS-LM0.01
96624 | 1.S | K09.96624 | 1.S | 887.22 | R-RS-LM0.01
96629 | 1.S | K09.96629 | 1.S | 186.77 | R-RS-LM0.01
96630 | 1.S | K09.96630 | 1.S | 241.42 | R-RS-LM0.01
96644 | 1.S | K09.96644 | 1.S | 1505.89 | R-RS-LM0.01
96652 | 1.S | K09.96652 | 1.S | 1505.89 | R-RS-LM0.01
96658 | 1.S | K09.96658 | 1.S | 858.52 | R-RS-LM0.01
96661 | 1.S | K09.96661 | 1.S | 382.22 | R-RS-LM0.01
96662 | 1.S | K09.96662 | 1.S | 241.42 | R-RS-LM0.01
96675 | 1.S | K09.96675 | 1.S | 120 | R-RS-LM0.01
96678 | 1.S | K09.96678 | 1.S | 547.86 | R-RS-LM0.01
96691 | 1.S | K09.96691 | 1.S | 233.27 | R-RS-LM0.01
96706 | 1.S | K09.96706 | 1.S | 140.72 | R-RS-LM0.01
96707 | 1.S | K09.96707 | 1.S | 241.42 | R-RS-LM0.01
96943 | 1.S | K09.96943 | 1.S | 151.39 | R-RS-VZT.01
96944 | 1.S | K09.96944 | 1.S | 1379.05 | R-RS-VZT.01
96947 | 1.S | K09.96947 | 1.S | 2323.79 | R-RS-VZT.01
96950 | 1.S | K09.96950 | 1.S | 4280.28 | R-RS-VZT.01
96953 | 1.S | K09.96953 | 1.S | 1891.22 | R-RS-VZT.01
96954 | 1.S | K09.96954 | 1.S | 950 | R-RS-VZT.01
97111 | 1.S | K09.97111 | 1.S | 2254.96 | R-RS-VZT.01
97128 | 1.S | K09.97128 | 1.S | 1400 | R-RS-VZT.01
97140 | 1.S | K09.97140 | 1.S | 528.82 | R-RS-VZT.01
97188 | 1.S | K09.97188 | 1.S | 719.33 | R-RS-VZT.01
97196 | 1.S | K09.97196 | 1.S | 850 | R-RS-VZT.01
97221 | 1.S | K09.97221 | 1.S | 480.54 | R-RS-VZT.01
97231 | 1.S | K09.97231 | 1.S | 2158.99 | R-RS-VZT.01
97288 | 1.S | K09.97288 | 1.S | 970 | R-RS-VZT.01
97318 | 1.S | K09.97318 | 1.S | 753.924 | R-RS-VZT.01
97335 | 1.S | K09.97335 | 1.S | 3719.54 | R-RS-VZT.01
97344 | 1.S | K09.97344 | 1.S | 120 | R-RS-VZT.01
97347 | 1.S | K09.97347 | 1.S | 1980.14 | R-RS-VZT.01
97359 | 1.S | K09.97359 | 1.S | 270 | R-RS-VZT.01
97376 | 1.S | K09.97376 | 1.S | 3725.99 | R-RS-VZT.01
97383 | 1.S | K09.97383 | 1.S | 120 | R-RS-VZT.01
97386 | 1.S | K09.97386 | 1.S | 2450.95 | R-RS-VZT.01
97398 | 1.S | K09.97398 | 1.S | 250 | R-RS-VZT.01
97415 | 1.S | K09.97415 | 1.S | 3644.15 | R-RS-VZT.01
97422 | 1.S | K09.97422 | 1.S | 120 | R-RS-VZT.01
97425 | 1.S | K09.97425 | 1.S | 7996.96 | R-RS-VZT.01
97437 | 1.S | K09.97437 | 1.S | 630 | R-RS-VZT.01
98379 | 1.S | K09.98379 | 1.S | 1515.29 | R-RS-LM0.02
98380 | 1.S | K09.98380 | 1.S | 1003.12 | R-RS-LM0.02
98387 | 1.S | K09.98387 | 1.S | 140.72 | R-RS-LM0.02
98388 | 1.S | K09.98388 | 1.S | 241.42 | R-RS-LM0.02
98400 | 1.S | K09.98400 | 1.S | 1515.29 | R-RS-LM0.02
98403 | 1.S | K09.98403 | 1.S | 1151.5 | R-RS-LM0.02
98413 | 1.S | K09.98413 | 1.S | 695.37 | R-RS-LM0.03
98414 | 1.S | K09.98414 | 1.S | 1493 | R-RS-LM0.03
98415 | 1.S | K09.98415 | 1.S | 1151.5 | R-RS-LM0.03
98426 | 1.S | K09.98426 | 1.S | 1493 | R-RS-LM0.03
98434 | 1.S | K09.98434 | 1.S | 1493 | R-RS-LM0.04
98445 | 1.S | K09.98445 | 1.S | 1493 | R-RS-LM0.04
98448 | 1.S | K09.98448 | 1.S | 1273.17 | R-RS-LM0.04
99281 | 1.S | K09.99281 | 1.S | 1407 | R-RS-LM0.05
99284 | 1.S | K09.99284 | 1.S | 1407 | R-RS-LM0.05
99308 | 1.S | K09.99308 | 1.S | 201.7 | R-RS-LM0.05
99311 | 1.S | K09.99311 | 1.S | 502.83 | R-RS-LM0.05
99326 | 1.S | K09.99326 | 1.S | 1550 | R-RS-LM0.06
99327 | 1.S | K09.99327 | 1.S | 1550 | R-RS-LM0.06
99334 | 1.S | K09.99334 | 1.S | 1084.77 | R-RS-LM0.06
99352 | 1.S | K09.99352 | 1.S | 1476.21 | R-RS-LM0.06
99365 | 1.S | K09.99365 | 1.S | 1331.15 | R-RS-LM0.06
99687 | 1.S | K09.99687 | 1.S | 1200 | R-RS-LM0.08/A
99688 | 1.S | K09.99688 | 1.S | 1270 | R-RS-LM0.08/A
99693 | 1.S | K09.99693 | 1.S | 1123.51 | R-RS-LM0.08/A
99697 | 1.S | K09.99697 | 1.S | 757.89 | R-RS-LM0.08/A
99772 | 1.S | K09.99772 | 1.S | 1600 | R-RS-LM0.09
99773 | 1.S | K09.99773 | 1.S | 850 | R-RS-LM0.09
99890 | 1.S | K09.99890 | 1.S | 525.37 | R-RS-LM0.09
99939 | 1.S | K09.99939 | 1.S | 519.63 | R-RS-LM0.09
100106 | 1.S | K09.100106 | 1.S | 224.6 | R-RS-LM0.08/B
100107 | 1.S | K09.100107 | 1.S | 57.57 | R-RS-LM0.08/B
100363 | 1.S | K09.100363 | 1.S | 140.72 | R-RS-LM0.06
100364 | 1.S | K09.100364 | 1.S | 241.42 | R-RS-LM0.06
100572 | 1.S | K09.100572 | 1.S | 140.72 | R-RS-LM0.05
100573 | 1.S | K09.100573 | 1.S | 241.42 | R-RS-LM0.05
100840 | 2.NP mezipatro | K09.100840 | 2.NP mezipatro | 2422.01 | R-RS-LM2.03
100841 | 2.NP mezipatro | K09.100841 | 2.NP mezipatro | 1231.17 | R-RS-LM2.03
100842 | 2.NP mezipatro | K09.100842 | 2.NP mezipatro | 4912.38 | R-RS-LM2.03
100845 | 2.NP mezipatro | K09.100845 | 2.NP mezipatro | 1286.01 | R-RS-LM2.03
100846 | 2.NP mezipatro | K09.100846 | 2.NP mezipatro | 350 | R-RS-LM2.03
100849 | 2.NP mezipatro | K09.100849 | 2.NP mezipatro | 621.016 | R-RS-LM2.03
100850 | 2.NP mezipatro | K09.100850 | 2.NP mezipatro | 4281.41 | R-RS-LM2.03
100851 | 2.NP mezipatro | K09.100851 | 2.NP mezipatro | 3650 | R-RS-LM2.03
100853 | 2.NP mezipatro | K09.100853 | 2.NP mezipatro | 109.41 | R-RS-LM2.03
100856 | 2.NP mezipatro | K09.100856 | 2.NP mezipatro | 7698.16 | R-RS-LM2.03
100859 | 2.NP mezipatro | K09.100859 | 2.NP mezipatro | 3307.63 | R-RS-LM2.03
100860 | 2.NP mezipatro | K09.100860 | 2.NP mezipatro | 964.49 | R-RS-LM2.03
100861 | 2.NP mezipatro | K09.100861 | 2.NP mezipatro | 4057.31 | R-RS-LM2.03
100864 | 2.NP mezipatro | K09.100864 | 2.NP mezipatro | 836.011 | R-RS-LM2.03
100867 | 2.NP mezipatro | K09.100867 | 2.NP mezipatro | 4092.7 | R-RS-LM2.03
100869 | 2.NP mezipatro | K09.100869 | 2.NP mezipatro | 343.64 | R-RS-LM2.03
100870 | 2.NP mezipatro | K09.100870 | 2.NP mezipatro | 5997.93 | R-RS-LM2.03
100873 | 2.NP mezipatro | K09.100873 | 2.NP mezipatro | 393.28 | R-RS-LM2.03
100876 | 2.NP mezipatro | K09.100876 | 2.NP mezipatro | 19645.3 | R-RS-LM2.03
100877 | 2.NP mezipatro | K09.100877 | 2.NP mezipatro | 1643.23 | R-RS-LM2.03
100878 | 2.NP mezipatro | K09.100878 | 2.NP mezipatro | 120 | R-RS-LM2.03
100880 | 2.NP mezipatro | K09.100880 | 2.NP mezipatro | 4859.12 | R-RS-LM2.03
100894 | 2.NP mezipatro | K09.100894 | 2.NP mezipatro | 129.045 | R-RS-LM2.03
100897 | 2.NP mezipatro | K09.100897 | 2.NP mezipatro | 12410.3 | R-RS-LM2.03
100898 | 2.NP mezipatro | K09.100898 | 2.NP mezipatro | 7914.35 | R-RS-LM2.03
100901 | 2.NP mezipatro | K09.100901 | 2.NP mezipatro | 2288.35 | R-RS-LM2.03
100904 | 2.NP mezipatro | K09.100904 | 2.NP mezipatro | 172.53 | R-RS-LM2.03
100905 | 2.NP mezipatro | K09.100905 | 2.NP mezipatro | 241.42 | R-RS-LM2.03
100915 | 2.NP mezipatro | K09.100915 | 2.NP mezipatro | 2817.14 | R-RS-LM2.03
100918 | 2.NP mezipatro | K09.100918 | 2.NP mezipatro | 120 | R-RS-LM2.03
100920 | 2.NP mezipatro | K09.100920 | 2.NP mezipatro | 8638.23 | R-RS-LM2.03
100926 | 2.NP mezipatro | K09.100926 | 2.NP mezipatro | 2769.31 | R-RS-LM2.03
100927 | 2.NP mezipatro | K09.100927 | 2.NP mezipatro | 2194.71 | R-RS-LM2.03
100928 | 2.NP mezipatro | K09.100928 | 2.NP mezipatro | 1695.64 | R-RS-LM2.03
100929 | 2.NP mezipatro | K09.100929 | 2.NP mezipatro | 5142.5 | R-RS-LM2.03
100935 | 2.NP mezipatro | K09.100935 | 2.NP mezipatro | 120 | R-RS-LM2.03
100937 | 2.NP mezipatro | K09.100937 | 2.NP mezipatro | 25148 | R-RS-LM2.03
100943 | 2.NP mezipatro | K09.100943 | 2.NP mezipatro | 1092.51 | R-RS-LM2.03
100946 | 2.NP mezipatro | K09.100946 | 2.NP mezipatro | 4115.91 | R-RS-LM2.03
100948 | 1.S | K09.100948 | 1.S | 136.39 | R-RS-LM2.03
100949 | 1.S | K09.100949 | 1.S | 1379.05 | R-RS-LM2.03
100952 | 1.S | K09.100952 | 1.S | 2338.79 | R-RS-LM2.03
100955 | 1.S | K09.100955 | 1.S | 7118.13 | R-RS-LM2.03
100958 | 1.S | K09.100958 | 1.S | 16091.5 | R-RS-LM2.03
100961 | 2.NP mezipatro | K09.100961 | 2.NP mezipatro | 7440 | R-RS-LM2.03
100962 | 1.S | K09.100962 | 1.S | 910 | R-RS-LM2.03
100965 | 2.NP mezipatro | K09.100965 | 2.NP mezipatro | 2263.79 | R-RS-LM2.03
100971 | 2.NP mezipatro | K09.100971 | 2.NP mezipatro | 6276.81 | R-RS-LM2.03
100975 | 2.NP mezipatro | K09.100975 | 2.NP mezipatro | 105.72 | R-RS-LM2.03
100976 | 2.NP mezipatro | K09.100976 | 2.NP mezipatro | 241.42 | R-RS-LM2.03
100986 | 2.NP mezipatro | K09.100986 | 2.NP mezipatro | 120 | R-RS-LM2.03
100988 | 2.NP mezipatro | K09.100988 | 2.NP mezipatro | 3612.18 | R-RS-LM2.03
101010 | 2.NP mezipatro | K09.101010 | 2.NP mezipatro | 5.76 | R-RS-LM2.03
101013 | 2.NP mezipatro | K09.101013 | 2.NP mezipatro | 2132.03 | R-RS-LM2.03
101022 | 2.NP mezipatro | K09.101022 | 2.NP mezipatro | 2258.75 | R-RS-LM2.03
101023 | 2.NP mezipatro | K09.101023 | 2.NP mezipatro | 120 | R-RS-LM2.03
101025 | 2.NP mezipatro | K09.101025 | 2.NP mezipatro | 214.26 | R-RS-LM2.03
101029 | 2.NP mezipatro | K09.101029 | 2.NP mezipatro | 1485.63 | R-RS-LM2.03
101032 | 2.NP mezipatro | K09.101032 | 2.NP mezipatro | 500 | R-RS-LM2.03
101035 | 2.NP mezipatro | K09.101035 | 2.NP mezipatro | 222.32 | R-RS-LM2.03
101039 | 2.NP mezipatro | K09.101039 | 2.NP mezipatro | 610 | R-RS-LM2.03
101042 | 2.NP mezipatro | K09.101042 | 2.NP mezipatro | 2641.29 | R-RS-LM2.03
101044 | 2.NP mezipatro | K09.101044 | 2.NP mezipatro | 5045.85 | R-RS-LM2.03
101045 | 2.NP mezipatro | K09.101045 | 2.NP mezipatro | 120 | R-RS-LM2.03
101047 | 2.NP mezipatro | K09.101047 | 2.NP mezipatro | 3376.97 | R-RS-LM2.03
101053 | 2.NP mezipatro | K09.101053 | 2.NP mezipatro | 276.56 | R-RS-LM2.03
101056 | 2.NP mezipatro | K09.101056 | 2.NP mezipatro | 2155 | R-RS-LM2.03
101059 | 2.NP mezipatro | K09.101059 | 2.NP mezipatro | 216.56 | R-RS-LM2.03
101062 | 2.NP mezipatro | K09.101062 | 2.NP mezipatro | 3520 | R-RS-LM2.03
101065 | 2.NP mezipatro | K09.101065 | 2.NP mezipatro | 250 | R-RS-LM2.03
101772 | 3.NP mezipatro | K09.101772 | 3.NP mezipatro | 2091.24 | R-RS-LM3.03
101773 | 3.NP mezipatro | K09.101773 | 3.NP mezipatro | 1485.63 | R-RS-LM3.03
101776 | 3.NP mezipatro | K09.101776 | 3.NP mezipatro | 579.75 | R-RS-LM3.03
101779 | 3.NP mezipatro | K09.101779 | 3.NP mezipatro | 376.075 | R-RS-LM3.03
101783 | 3.NP mezipatro | K09.101783 | 3.NP mezipatro | 610 | R-RS-LM3.03
101786 | 3.NP mezipatro | K09.101786 | 3.NP mezipatro | 2627.53 | R-RS-LM3.03
101788 | 3.NP mezipatro | K09.101788 | 3.NP mezipatro | 5315.85 | R-RS-LM3.03
101791 | 3.NP mezipatro | K09.101791 | 3.NP mezipatro | 276.56 | R-RS-LM3.03
101794 | 3.NP mezipatro | K09.101794 | 3.NP mezipatro | 1885 | R-RS-LM3.03
101797 | 3.NP mezipatro | K09.101797 | 3.NP mezipatro | 216.56 | R-RS-LM3.03
101800 | 3.NP mezipatro | K09.101800 | 3.NP mezipatro | 3520 | R-RS-LM3.03
101803 | 3.NP mezipatro | K09.101803 | 3.NP mezipatro | 250 | R-RS-LM3.03
101878 | 3.NP mezipatro | K09.101878 | 3.NP mezipatro | 120 | R-RS-LM3.03
101891 | 3.NP mezipatro | K09.101891 | 3.NP mezipatro | 120 | R-RS-LM3.03
101894 | 3.NP mezipatro | K09.101894 | 3.NP mezipatro | 294.013 | R-RS-LM3.03
102568 | 3.NP | K09.102568 | 3.NP | 879.98 | R-RS-LM3.13
102569 | 3.NP | K09.102569 | 3.NP | 12184.1 | R-RS-LM3.13
102572 | 3.NP | K09.102572 | 3.NP | 26200.7 | R-RS-LM3.13
102573 | 3.NP | K09.102573 | 3.NP | 3541.34 | R-RS-LM3.13
102574 | 3.NP | K09.102574 | 3.NP | 4033.45 | R-RS-LM3.13
102575 | 3.NP | K09.102575 | 3.NP | 3539.55 | R-RS-LM3.13
102576 | 3.NP | K09.102576 | 3.NP | 7283.68 | R-RS-LM3.13
102577 | 3.NP | K09.102577 | 3.NP | 1179.04 | R-RS-LM3.13
102578 | 3.NP | K09.102578 | 3.NP | 2422.34 | R-RS-LM3.13
102579 | 3.NP | K09.102579 | 3.NP | 1205.8 | R-RS-LM3.13
102581 | 3.NP | K09.102581 | 3.NP | 4673.5 | R-RS-LM3.13
102582 | 3.NP | K09.102582 | 3.NP | 12152.3 | R-RS-LM3.13
102583 | 3.NP | K09.102583 | 3.NP | 7440 | R-RS-LM3.13
102585 | 3.NP | K09.102585 | 3.NP | 4806.45 | R-RS-LM3.13
102586 | 3.NP | K09.102586 | 3.NP | 70.33 | R-RS-LM3.13
102588 | 3.NP | K09.102588 | 3.NP | 4795.86 | R-RS-LM3.13
102593 | 3.NP | K09.102593 | 3.NP | 4785.47 | R-RS-LM3.13
102595 | 3.NP | K09.102595 | 3.NP | 1447.01 | R-RS-LM3.13
102596 | 3.NP | K09.102596 | 3.NP | 2988.14 | R-RS-LM3.13
102601 | 3.NP | K09.102601 | 3.NP | 5750 | R-RS-LM3.13
102610 | 3.NP | K09.102610 | 3.NP | 2632.84 | R-RS-LM3.13
102611 | 3.NP | K09.102611 | 3.NP | 3661.42 | R-RS-LM3.13
102612 | 3.NP | K09.102612 | 3.NP | 149.65 | R-RS-LM3.13
102613 | 3.NP | K09.102613 | 3.NP | 7695.95 | R-RS-LM3.13
102620 | 3.NP | K09.102620 | 3.NP | 3963.77 | R-RS-LM3.13
102626 | 3.NP | K09.102626 | 3.NP | 120 | R-RS-LM3.13
102632 | 3.NP | K09.102632 | 3.NP | 120 | R-RS-LM3.13
102639 | 3.NP | K09.102639 | 3.NP | 245.64 | R-RS-LM3.13
102640 | 3.NP | K09.102640 | 3.NP | 241.42 | R-RS-LM3.13
102649 | 3.NP | K09.102649 | 3.NP | 120 | R-RS-LM3.13
102651 | 3.NP | K09.102651 | 3.NP | 1887.61 | R-RS-LM3.13
102658 | 3.NP | K09.102658 | 3.NP | 120 | R-RS-LM3.13
102660 | 3.NP | K09.102660 | 3.NP | 9341.52 | R-RS-LM3.13
102666 | 3.NP | K09.102666 | 3.NP | 120 | R-RS-LM3.13
102668 | 3.NP | K09.102668 | 3.NP | 7878.14 | R-RS-LM3.13
102673 | 3.NP | K09.102673 | 3.NP | 279.37 | R-RS-LM3.13
102674 | 3.NP | K09.102674 | 3.NP | 241.42 | R-RS-LM3.13
102686 | 3.NP | K09.102686 | 3.NP | 3785.1 | R-RS-LM3.13
102687 | 3.NP | K09.102687 | 3.NP | 1092.92 | R-RS-LM3.13
102688 | 3.NP | K09.102688 | 3.NP | 2200.97 | R-RS-LM3.13
102689 | 3.NP | K09.102689 | 3.NP | 5150 | R-RS-LM3.13
102695 | 3.NP | K09.102695 | 3.NP | 120 | R-RS-LM3.13
102697 | 3.NP | K09.102697 | 3.NP | 7226.75 | R-RS-LM3.13
102704 | 3.NP | K09.102704 | 3.NP | 6250.67 | R-RS-LM3.13
102709 | 3.NP | K09.102709 | 3.NP | 8920 | R-RS-LM3.13
102710 | 1.S | K09.102710 | 1.S | 151.39 | R-RS-LM3.13
102711 | 1.S | K09.102711 | 1.S | 1379.05 | R-RS-LM3.13
102714 | 1.S | K09.102714 | 1.S | 2308.79 | R-RS-LM3.13
102717 | 1.S | K09.102717 | 1.S | 6916.53 | R-RS-LM3.13
102720 | 1.S | K09.102720 | 1.S | 16056.5 | R-RS-LM3.13
102721 | 1.S | K09.102721 | 1.S | 930 | R-RS-LM3.13
102734 | 3.NP | K09.102734 | 3.NP | 4026.33 | R-RS-LM3.13
103451 | 1.S mezipatro | K09.103451 | 1.S mezipatro | 1300.38 | R-RS-LM0.13
103452 | 1.S mezipatro | K09.103452 | 1.S mezipatro | 1498.23 | R-RS-LM0.13
103453 | 1.S mezipatro | K09.103453 | 1.S mezipatro | 3900 | R-RS-LM0.13
103456 | 1.S mezipatro | K09.103456 | 1.S mezipatro | 1438.23 | R-RS-LM0.13
103460 | 1.S mezipatro | K09.103460 | 1.S mezipatro | 79.946 | R-RS-LM0.13
103461 | 1.S mezipatro | K09.103461 | 1.S mezipatro | 4345.25 | R-RS-LM0.13
103462 | 1.S mezipatro | K09.103462 | 1.S mezipatro | 3640.64 | R-RS-LM0.13
103464 | 1.S mezipatro | K09.103464 | 1.S mezipatro | 151.11 | R-RS-LM0.13
103467 | 1.S mezipatro | K09.103467 | 1.S mezipatro | 7690 | R-RS-LM0.13
103470 | 1.S mezipatro | K09.103470 | 1.S mezipatro | 3104.7 | R-RS-LM0.13
103471 | 1.S mezipatro | K09.103471 | 1.S mezipatro | 845.013 | R-RS-LM0.13
103472 | 1.S mezipatro | K09.103472 | 1.S mezipatro | 2915 | R-RS-LM0.13
103475 | 1.S mezipatro | K09.103475 | 1.S mezipatro | 955.48 | R-RS-LM0.13
103478 | 1.S mezipatro | K09.103478 | 1.S mezipatro | 5709.37 | R-RS-LM0.13
103480 | 1.S mezipatro | K09.103480 | 1.S mezipatro | 113.61 | R-RS-LM0.13
103481 | 1.S mezipatro | K09.103481 | 1.S mezipatro | 5997.93 | R-RS-LM0.13
103484 | 1.S mezipatro | K09.103484 | 1.S mezipatro | 163.25 | R-RS-LM0.13
103487 | 1.S mezipatro | K09.103487 | 1.S mezipatro | 19678.8 | R-RS-LM0.13
103488 | 1.S mezipatro | K09.103488 | 1.S mezipatro | 1679.67 | R-RS-LM0.13
103489 | 1.S mezipatro | K09.103489 | 1.S mezipatro | 120 | R-RS-LM0.13
103491 | 1.S mezipatro | K09.103491 | 1.S mezipatro | 4395.38 | R-RS-LM0.13
103497 | 1.S mezipatro | K09.103497 | 1.S mezipatro | 1370.87 | R-RS-LM0.13
103498 | 1.S mezipatro | K09.103498 | 1.S mezipatro | 120 | R-RS-LM0.13
103500 | 1.S mezipatro | K09.103500 | 1.S mezipatro | 264.37 | R-RS-LM0.13
103505 | 1.S mezipatro | K09.103505 | 1.S mezipatro | 1859.95 | R-RS-LM0.13
103508 | 1.S mezipatro | K09.103508 | 1.S mezipatro | 11583 | R-RS-LM0.13
103509 | 1.S mezipatro | K09.103509 | 1.S mezipatro | 8162.83 | R-RS-LM0.13
103512 | 1.S mezipatro | K09.103512 | 1.S mezipatro | 1894.5 | R-RS-LM0.13
103515 | 1.S mezipatro | K09.103515 | 1.S mezipatro | 155.72 | R-RS-LM0.13
103516 | 1.S mezipatro | K09.103516 | 1.S mezipatro | 241.42 | R-RS-LM0.13
103526 | 1.S mezipatro | K09.103526 | 1.S mezipatro | 2291.64 | R-RS-LM0.13
103529 | 1.S mezipatro | K09.103529 | 1.S mezipatro | 120 | R-RS-LM0.13
103531 | 1.S mezipatro | K09.103531 | 1.S mezipatro | 7409.29 | R-RS-LM0.13
103537 | 1.S mezipatro | K09.103537 | 1.S mezipatro | 2291.64 | R-RS-LM0.13
103538 | 1.S mezipatro | K09.103538 | 1.S mezipatro | 49.89 | R-RS-LM0.13
103539 | 1.S mezipatro | K09.103539 | 1.S mezipatro | 38.051 | R-RS-LM0.13
103540 | 1.S mezipatro | K09.103540 | 1.S mezipatro | 5142.5 | R-RS-LM0.13
103546 | 1.S mezipatro | K09.103546 | 1.S mezipatro | 120 | R-RS-LM0.13
103548 | 1.S mezipatro | K09.103548 | 1.S mezipatro | 25187.5 | R-RS-LM0.13
103554 | 1.S mezipatro | K09.103554 | 1.S mezipatro | 982.089 | R-RS-LM0.13
103557 | 1.S mezipatro | K09.103557 | 1.S mezipatro | 3929.92 | R-RS-LM0.13
103559 | 1.S | K09.103559 | 1.S | 128.022 | R-RS-LM0.13
103560 | 1.S | K09.103560 | 1.S | 1358.05 | R-RS-LM0.13
103563 | 1.S | K09.103563 | 1.S | 2356.57 | R-RS-LM0.13
103566 | 1.S | K09.103566 | 1.S | 6952.03 | R-RS-LM0.13
103569 | 1.S | K09.103569 | 1.S | 16108 | R-RS-LM0.13
103572 | 1.S mezipatro | K09.103572 | 1.S mezipatro | 1480 | R-RS-LM0.13
103573 | 1.S | K09.103573 | 1.S | 870 | R-RS-LM0.13
103576 | 1.S mezipatro | K09.103576 | 1.S mezipatro | 2406.18 | R-RS-LM0.13
103582 | 1.S mezipatro | K09.103582 | 1.S mezipatro | 5191.9 | R-RS-LM0.13
103586 | 1.S mezipatro | K09.103586 | 1.S mezipatro | 105.72 | R-RS-LM0.13
103587 | 1.S mezipatro | K09.103587 | 1.S mezipatro | 241.42 | R-RS-LM0.13
103597 | 1.S mezipatro | K09.103597 | 1.S mezipatro | 120 | R-RS-LM0.13
103599 | 1.S mezipatro | K09.103599 | 1.S mezipatro | 4149.44 | R-RS-LM0.13
103624 | 1.S mezipatro | K09.103624 | 1.S mezipatro | 2668.09 | R-RS-LM0.13
103633 | 1.S mezipatro | K09.103633 | 1.S mezipatro | 1822.3 | R-RS-LM0.13
103634 | 1.S mezipatro | K09.103634 | 1.S mezipatro | 120 | R-RS-LM0.13
103636 | 1.S mezipatro | K09.103636 | 1.S mezipatro | 214.26 | R-RS-LM0.13
103640 | 1.S mezipatro | K09.103640 | 1.S mezipatro | 1485.63 | R-RS-LM0.13
103643 | 1.S mezipatro | K09.103643 | 1.S mezipatro | 500 | R-RS-LM0.13
103646 | 1.S mezipatro | K09.103646 | 1.S mezipatro | 622.32 | R-RS-LM0.13
103650 | 1.S mezipatro | K09.103650 | 1.S mezipatro | 610 | R-RS-LM0.13
103653 | 1.S mezipatro | K09.103653 | 1.S mezipatro | 2604.84 | R-RS-LM0.13
103655 | 1.S mezipatro | K09.103655 | 1.S mezipatro | 5590.85 | R-RS-LM0.13
103656 | 1.S mezipatro | K09.103656 | 1.S mezipatro | 120 | R-RS-LM0.13
103658 | 1.S mezipatro | K09.103658 | 1.S mezipatro | 2840.9 | R-RS-LM0.13
103664 | 1.S mezipatro | K09.103664 | 1.S mezipatro | 276.56 | R-RS-LM0.13
103667 | 1.S mezipatro | K09.103667 | 1.S mezipatro | 1610 | R-RS-LM0.13
103670 | 1.S mezipatro | K09.103670 | 1.S mezipatro | 216.56 | R-RS-LM0.13
103673 | 1.S mezipatro | K09.103673 | 1.S mezipatro | 3520 | R-RS-LM0.13
103676 | 1.S mezipatro | K09.103676 | 1.S mezipatro | 250 | R-RS-LM0.13
119696 | 3.NP mezipatro | K09.119696 | 3.NP mezipatro | 120 | R-RS-LM3.03
119699 | 3.NP mezipatro | K09.119699 | 3.NP mezipatro | 4051.41 | R-RS-LM3.03
119781 | 3.NP mezipatro | K09.119781 | 3.NP mezipatro | 120 | R-RS-LM3.03
119784 | 3.NP mezipatro | K09.119784 | 3.NP mezipatro | 19622 | R-RS-LM3.03
119948 | 3.NP | K09.119948 | 3.NP | 879.98 | R-RS-LM3.14
119954 | 3.NP | K09.119954 | 3.NP | 120 | R-RS-LM3.14
119957 | 3.NP | K09.119957 | 3.NP | 569.096 | R-RS-LM3.14
119982 | 3.NP | K09.119982 | 3.NP | 100 | R-RS-LM3.14
119993 | 3.NP | K09.119993 | 3.NP | 120 | R-RS-LM3.14
119996 | 3.NP | K09.119996 | 3.NP | 3753.17 | R-RS-LM3.14
120008 | 3.NP | K09.120008 | 3.NP | 120 | R-RS-LM3.14
120011 | 3.NP | K09.120011 | 3.NP | 6889.46 | R-RS-LM3.14
125765 | 4.NP mezipatro | K09.125765 | 4.NP mezipatro | 254.12 | R-RS-LM4.04
126017 | 4.NP mezipatro | K09.126017 | 4.NP mezipatro | 7100 | R-RS-LM4.03
126050 | 4.NP mezipatro | K09.126050 | 4.NP mezipatro | 760 | R-RS-LM4.03
126122 | 4.NP mezipatro | K09.126122 | 4.NP mezipatro | 550 | R-RS-LM4.03
126290 | 3.NP mezipatro | K09.126290 | 3.NP mezipatro | 700 | R-RS-LM3.03
126300 | 3.NP mezipatro | K09.126300 | 3.NP mezipatro | 700 | R-RS-LM3.03
126329 | 3.NP mezipatro | K09.126329 | 3.NP mezipatro | 246.38 | R-RS-LM3.03
126404 | 3.NP mezipatro | K09.126404 | 3.NP mezipatro | 3811.01 | R-RS-LM3.03
126536 | 3.NP mezipatro | K09.126536 | 3.NP mezipatro | 76.4 | R-RS-LM4.14
126952 | 3.NP mezipatro | K09.126952 | 3.NP mezipatro | 1156.29 | R-RS-LM3.04
126980 | 3.NP mezipatro | K09.126980 | 3.NP mezipatro | 1800 | R-RS-LM3.04
127011 | 3.NP mezipatro | K09.127011 | 3.NP mezipatro | 4115.57 | R-RS-LM3.04
127038 | 3.NP mezipatro | K09.127038 | 3.NP mezipatro | 200 | R-RS-LM3.04
127090 | 3.NP mezipatro | K09.127090 | 3.NP mezipatro | 120 | R-RS-LM3.04
127093 | 3.NP mezipatro | K09.127093 | 3.NP mezipatro | 1198.59 | R-RS-LM3.04
127166 | 3.NP | K09.127166 | 3.NP | 100 | R-RS-LM3.14
127351 | 2.NP mezipatro | K09.127351 | 2.NP mezipatro | 1240.85 | R-RS-LM2.04
127375 | 2.NP mezipatro | K09.127375 | 2.NP mezipatro | 1195.56 | R-RS-LM2.04
127405 | 2.NP mezipatro | K09.127405 | 2.NP mezipatro | 3692.57 | R-RS-LM2.04
127429 | 2.NP mezipatro | K09.127429 | 2.NP mezipatro | 444.44 | R-RS-LM2.04
127494 | 2.NP mezipatro | K09.127494 | 2.NP mezipatro | 120 | R-RS-LM2.04
127497 | 2.NP mezipatro | K09.127497 | 2.NP mezipatro | 2299.36 | R-RS-LM2.04
127668 | 4.NP | K09.127668 | 4.NP | 598.89 | R-RS-LM4.14
127679 | 4.NP | K09.127679 | 4.NP | 100 | R-RS-LM4.14
127903 | 4.NP | K09.127903 | 4.NP | 152.64 | R-RS-LM4.13
127935 | 4.NP | K09.127935 | 4.NP | 5310.4 | R-RS-LM4.13
128096 | 3.NP | K09.128096 | 3.NP | 2607.91 | R-RS-LM3.13
128122 | 3.NP | K09.128122 | 3.NP | 2490.71 | R-RS-LM3.13
128152 | 3.NP | K09.128152 | 3.NP | 87.69 | R-RS-LM3.13
128228 | 3.NP | K09.128228 | 3.NP | 59.87 | R-RS-LM3.13
128524 | 2.NP | K09.128524 | 2.NP | 2687.51 | R-RS-LM2.13
128549 | 2.NP | K09.128549 | 2.NP | 2003.16 | R-RS-LM2.13
128622 | 2.NP | K09.128622 | 2.NP | 126.65 | R-RS-LM2.13
128681 | 2.NP | K09.128681 | 2.NP | 2083.78 | R-RS-LM2.13
128709 | 2.NP | K09.128709 | 2.NP | 964.093 | R-RS-LM2.13
128860 | 2.NP mezipatro | K09.128860 | 2.NP mezipatro | 1852.27 | R-RS-LM2.03
128890 | 2.NP mezipatro | K09.128890 | 2.NP mezipatro | 1057.93 | R-RS-LM2.03
128950 | 2.NP mezipatro | K09.128950 | 2.NP mezipatro | 120 | R-RS-LM2.03
128953 | 2.NP mezipatro | K09.128953 | 2.NP mezipatro | 1707.36 | R-RS-LM2.03
129037 | 1.NP | K09.129037 | 1.NP | 2051.39 | R-RS-LM1.14
129065 | 1.NP | K09.129065 | 1.NP | 1000 | R-RS-LM1.14
129142 | 1.NP | K09.129142 | 1.NP | 2100 | R-RS-LM1.14
129169 | 1.NP | K09.129169 | 1.NP | 890.71 | R-RS-LM1.14
129252 | 1.NP | K09.129252 | 1.NP | 914.957 | R-RS-LM1.14
129280 | 1.NP | K09.129280 | 1.NP | 2075.59 | R-RS-LM1.14
129389 | 1.NP | K09.129389 | 1.NP | 2666.6 | R-RS-LM1.13
129416 | 1.NP | K09.129416 | 1.NP | 2151.72 | R-RS-LM1.13
129499 | 1.NP | K09.129499 | 1.NP | 126.65 | R-RS-LM1.13
129619 | 1.NP mezipatro | K09.129619 | 1.NP mezipatro | 1109.77 | R-RS-LM1.06
129644 | 1.NP mezipatro | K09.129644 | 1.NP mezipatro | 120 | R-RS-LM1.06
129647 | 1.NP mezipatro | K09.129647 | 1.NP mezipatro | 1616.93 | R-RS-LM1.06
129798 | 1.NP mezipatro | K09.129798 | 1.NP mezipatro | 1027.88 | R-RS-LM1.05
129897 | 1.NP mezipatro | K09.129897 | 1.NP mezipatro | 1340 | R-RS-LM1.05
129924 | 1.NP mezipatro | K09.129924 | 1.NP mezipatro | 1038.37 | R-RS-LM1.05
130002 | 1.NP mezipatro | K09.130002 | 1.NP mezipatro | 3071.9 | R-RS-LM1.05
130031 | 1.NP mezipatro | K09.130031 | 1.NP mezipatro | 1709.29 | R-RS-LM1.05
130068 | 1.NP mezipatro | K09.130068 | 1.NP mezipatro | 90.71 | R-RS-LM1.05
130099 | 1.NP mezipatro | K09.130099 | 1.NP mezipatro | 1480 | R-RS-LM1.05
130185 | 1.NP mezipatro | K09.130185 | 1.NP mezipatro | 120 | R-RS-LM1.05
130188 | 1.NP mezipatro | K09.130188 | 1.NP mezipatro | 2598.91 | R-RS-LM1.05
130371 | 1.S mezipatro | K09.130371 | 1.S mezipatro | 955.11 | R-RS-LM0.13
130397 | 1.S mezipatro | K09.130397 | 1.S mezipatro | 1160.53 | R-RS-LM0.13
130612 | 1.S mezipatro | K09.130612 | 1.S mezipatro | 1750.47 | R-RS-LM0.12
130635 | 1.S mezipatro | K09.130635 | 1.S mezipatro | 920 | R-RS-LM0.12
130871 | 1.S mezipatro | K09.130871 | 1.S mezipatro | 5139.14 | R-RS-LM0.12
131223 | 1.S | K09.131223 | 1.S | 4260.62 | R-RS-LM0.10
131441 | 1.S | K09.131441 | 1.S | 6205.81 | R-RS-LM0.10
131481 | 1.S | K09.131481 | 1.S | 1147.73 | R-RS-LM0.10
131504 | 1.S | K09.131504 | 1.S | 200 | R-RS-LM0.10
131507 | 1.S | K09.131507 | 1.S | 198.89 | R-RS-LM0.10
131599 | 1.S | K09.131599 | 1.S | 200 | R-RS-LM0.10
131602 | 1.S | K09.131602 | 1.S | 848.35 | R-RS-LM0.10
131796 | 1.S mezipatro | K09.131796 | 1.S mezipatro | 410 | R-RS-LM0.08/C
131960 | 1.S | K09.131960 | 1.S | 114.65 | R-RS-LM0.02
143501 | 1.S | K09.143501 | 1.S | 88.019 | R-RS-LM0.08/A
143644 | 1.S | K09.143644 | 1.S | 55.921 | R-RS-LM0.08/C
193479 | 1.S | K09.193479 | 1.S | 648.8 | R-RS-VZT.01
193498 | 1.S | K09.193498 | 1.S | 120 | R-RS-VZT.01
193501 | 1.S | K09.193501 | 1.S | 2769.9 | R-RS-VZT.01
193583 | 1.S | K09.193583 | 1.S | 184.7 | R-RS-VZT.01
193613 | 1.S | K09.193613 | 1.S | 450 | R-RS-VZT.01
193654 | 1.S | K09.193654 | 1.S | 940 | R-RS-VZT.01
200189 | 1.S | K09.200189 | 1.S | 1900 | R-RS-LM0.09
201102 | 1.S mezipatro | K09.201102 | 1.S mezipatro | 336.013 | R-RS-LM1.02
201540 | 4.NP | K09.201540 | 4.NP | 336.013 | R-RS-LM1.02
201715 | 3.NP mezipatro | K09.201715 | 3.NP mezipatro | 336.013 | R-RS-LM1.02
201859 | 2.NP mezipatro | K09.201859 | 2.NP mezipatro | 336.013 | R-RS-LM1.02
202010 | 1.NP mezipatro | K09.202010 | 1.NP mezipatro | 336.013 | R-RS-LM1.02
202390 | 2.NP mezipatro | K09.202390 | 2.NP mezipatro | 524.41 | R-RS-LM1.01
202801 | 2.NP mezipatro | K09.202801 | 2.NP mezipatro | 2039.24 | R-RS-LM1.01
202835 | 3.NP mezipatro | K09.202835 | 3.NP mezipatro | 2039.24 | R-RS-LM1.01
202875 | 1.NP mezipatro | K09.202875 | 1.NP mezipatro | 524.41 | R-RS-LM1.01
202897 | 1.S mezipatro | K09.202897 | 1.S mezipatro | 2039.24 | R-RS-LM1.01
202993 | 3.NP mezipatro | K09.202993 | 3.NP mezipatro | 524.41 | R-RS-LM1.01
203057 | 1.NP mezipatro | K09.203057 | 1.NP mezipatro | 2039.24 | R-RS-LM1.01
203101 | 1.S mezipatro | K09.203101 | 1.S mezipatro | 524.41 | R-RS-LM1.01
203309 | 1.S | K09.203309 | 1.S | 2019.26 | R-RS-LM1.01
203376 | 1.S | K09.203376 | 1.S | 399.999 | R-RS-LM1.01
203456 | 1.S | K09.203456 | 1.S | 737.999 | R-RS-LM1.01
203648 | 4.NP mezipatro | K09.203648 | 4.NP mezipatro | 820 | R-RS-LM1.01
203735 | 4.NP | K09.203735 | 4.NP | 2618 | R-RS-LM1.01
204186 | 1.S mezipatro | K09.204186 | 1.S mezipatro | 215.3 | R-RS-LM0.13
204215 | 1.S mezipatro | K09.204215 | 1.S mezipatro | 3885.13 | R-RS-LM0.13
205835 | 1.S | K09.205835 | 1.S | 1460 | R-RS-EZS
205836 | 1.S | K09.205836 | 1.S | 2462.61 | R-RS-EZS
205839 | 1.S | K09.205839 | 1.S | 6933.98 | R-RS-EZS
205842 | 1.S | K09.205842 | 1.S | 91.39 | R-RS-EZS
205845 | 1.S | K09.205845 | 1.S | 870 | R-RS-EZS
205846 | 1.S | K09.205846 | 1.S | 7583.48 | R-RS-EZS
205847 | 1.S | K09.205847 | 1.S | 2714.22 | R-RS-EZS
205850 | 1.S | K09.205850 | 1.S | 1150 | R-RS-EZS
205853 | 1.S | K09.205853 | 1.S | 180 | R-RS-EZS
207645 | 1.S | K09.207645 | 1.S | 4093.86 | R-RS-LM0.11
207726 | 1.S | K09.207726 | 1.S | 200 | R-RS-LM0.11
207729 | 1.S | K09.207729 | 1.S | 4321.85 | R-RS-LM0.11
207870 | 1.S | K09.207870 | 1.S | 1293.86 | R-RS-LM0.11
230550 | 1.S | K09.230550 | 1.S | 150 | R-RS-LM0.09
231698 | 5.NP mezipatro | K09.231698 | 5.NP mezipatro | 1700 | R-RS-LM5.04
231805 | 5.NP mezipatro | K09.231805 | 5.NP mezipatro | 2100 | R-RS-LM5.04
231954 | 5.NP | K09.231954 | 5.NP | 897.25 | R-RS-LM5.04

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x120+70 + CYA25ZŽ (4)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificDescription: CYKY-J 3x120+70 + CYA25ZŽ; ElementProjectSpecificIdentifier: K13; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x120+70 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x120+70 + CYA25ZŽ:...) | Reference | Length
115165 | K13.115165 | 1455
115171 | K13.115171 | 541.925
115486 | K13.115486 | 1400
115499 | K13.115499 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x2,5 (239)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x2,5; ElementProjectSpecificDescription: CYKY-J 3x2,5; ElementProjectSpecificIdentifier: K10; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x2,5
Pset_DistributionSystemCommon - Reference: R-RS
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x2,5:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
81231 | 1.S | K10.81231 | 1.S | 1385 | R-RS-Z0.02
81237 | 1.S | K10.81237 | 1.S | 2312.61 | R-RS-Z0.02
81265 | 1.S | K10.81265 | 1.S | 772.16 | R-RS-Z0.02
81280 | 1.S | K10.81280 | 1.S | 5000 | R-RS-Z0.02
81319 | 1.S | K10.81319 | 1.S | 2320 | R-RS-Z0.02
81322 | 1.S | K10.81322 | 1.S | 305.7 | R-RS-Z0.02
81351 | 1.S | K10.81351 | 1.S | 2450 | R-RS-Z0.02
81503 | 1.S | K10.81503 | 1.S | 166.39 | R-RS-Z0.02
81554 | 1.S | K10.81554 | 1.S | 1250 | R-RS-Z0.02
81577 | 1.S | K10.81577 | 1.S | 140.72 | R-RS-Z0.02
81578 | 1.S | K10.81578 | 1.S | 241.42 | R-RS-Z0.02
81637 | 1.S | K10.81637 | 1.S | 1370 | R-RS-Z0.03
81638 | 1.S | K10.81638 | 1.S | 2282.61 | R-RS-Z0.03
81641 | 1.S | K10.81641 | 1.S | 6768.98 | R-RS-Z0.03
81644 | 1.S | K10.81644 | 1.S | 181.39 | R-RS-Z0.03
81648 | 1.S | K10.81648 | 1.S | 1170 | R-RS-Z0.03
81697 | 1.S | K10.81697 | 1.S | 1734.17 | R-RS-Z0.03
81716 | 1.S | K10.81716 | 1.S | 2912.86 | R-RS-Z0.03
81793 | 1.S | K10.81793 | 1.S | 2400 | R-RS-Z0.03
81821 | 1.S | K10.81821 | 1.S | 140.72 | R-RS-Z0.03
81822 | 1.S | K10.81822 | 1.S | 354.56 | R-RS-Z0.03
81898 | 1.S | K10.81898 | 1.S | 1400 | R-RS-Z0.04
81899 | 1.S | K10.81899 | 1.S | 2342.61 | R-RS-Z0.04
81902 | 1.S | K10.81902 | 1.S | 6813.98 | R-RS-Z0.04
81905 | 1.S | K10.81905 | 1.S | 151.39 | R-RS-Z0.04
81908 | 1.S | K10.81908 | 1.S | 1170 | R-RS-Z0.04
81911 | 1.S | K10.81911 | 1.S | 1749.17 | R-RS-Z0.04
81912 | 1.S | K10.81912 | 1.S | 5026.24 | R-RS-Z0.04
81913 | 1.S | K10.81913 | 1.S | 2450 | R-RS-Z0.04
81974 | 1.S | K10.81974 | 1.S | 140.72 | R-RS-Z0.04
81975 | 1.S | K10.81975 | 1.S | 354.56 | R-RS-Z0.04
82017 | 1.S | K10.82017 | 1.S | 1770 | R-RS-Z0.05
82023 | 1.S | K10.82023 | 1.S | 783.949 | R-RS-Z0.05
82107 | 1.S | K10.82107 | 1.S | 2450 | R-RS-Z0.05
82138 | 1.S | K10.82138 | 1.S | 61.39 | R-RS-Z0.05
82158 | 1.S | K10.82158 | 1.S | 1250 | R-RS-Z0.05
82223 | 1.S | K10.82223 | 1.S | 50.72 | R-RS-Z0.05
82224 | 1.S | K10.82224 | 1.S | 241.42 | R-RS-Z0.05
82275 | 1.S | K10.82275 | 1.S | 1785 | R-RS-Z0.06
82276 | 1.S | K10.82276 | 1.S | 2853.25 | R-RS-Z0.06
82277 | 1.S | K10.82277 | 1.S | 2450 | R-RS-Z0.06
82278 | 1.S | K10.82278 | 1.S | 76.39 | R-RS-Z0.06
82281 | 1.S | K10.82281 | 1.S | 1250 | R-RS-Z0.06
82284 | 1.S | K10.82284 | 1.S | 65.72 | R-RS-Z0.06
82285 | 1.S | K10.82285 | 1.S | 241.42 | R-RS-Z0.06
82398 | 1.S | K10.82398 | 1.S | 1355 | R-RS-Z0.07
82399 | 1.S | K10.82399 | 1.S | 2252.61 | R-RS-Z0.07
82402 | 1.S | K10.82402 | 1.S | 6738.98 | R-RS-Z0.07
82405 | 1.S | K10.82405 | 1.S | 196.39 | R-RS-Z0.07
82408 | 1.S | K10.82408 | 1.S | 1170 | R-RS-Z0.07
82411 | 1.S | K10.82411 | 1.S | 13817 | R-RS-Z0.07
82486 | 1.S | K10.82486 | 1.S | 233.23 | R-RS-Z0.07
82501 | 1.S | K10.82501 | 1.S | 3431.57 | R-RS-Z0.07
82520 | 1.S | K10.82520 | 1.S | 2450 | R-RS-Z0.07
82541 | 1.S | K10.82541 | 1.S | 2370 | R-RS-Z0.07
82544 | 1.S | K10.82544 | 1.S | 1743.61 | R-RS-Z0.07
82633 | 1.S | K10.82633 | 1.S | 45.72 | R-RS-Z0.07
82634 | 1.S | K10.82634 | 1.S | 354.56 | R-RS-Z0.07
84175 | 1.S | K10.84175 | 1.S | 1415 | R-RS-Z0.08
84176 | 1.S | K10.84176 | 1.S | 2372.61 | R-RS-Z0.08
84179 | 1.S | K10.84179 | 1.S | 6843.98 | R-RS-Z0.08
84182 | 1.S | K10.84182 | 1.S | 136.39 | R-RS-Z0.08
84185 | 1.S | K10.84185 | 1.S | 1250 | R-RS-Z0.08
84188 | 1.S | K10.84188 | 1.S | 13525.6 | R-RS-Z0.08
84221 | 1.S | K10.84221 | 1.S | 4250 | R-RS-Z0.08
84224 | 1.S | K10.84224 | 1.S | 960 | R-RS-Z0.08
84229 | 1.S | K10.84229 | 1.S | 2835.04 | R-RS-Z0.08
84243 | 1.S | K10.84243 | 1.S | 545.59 | R-RS-Z0.08
84247 | 1.S | K10.84247 | 1.S | 2450 | R-RS-Z0.08
85172 | 1.S | K10.85172 | 1.S | 1340 | R-RS-Z0.09
85173 | 1.S | K10.85173 | 1.S | 2222.61 | R-RS-Z0.09
85176 | 1.S | K10.85176 | 1.S | 6708.98 | R-RS-Z0.09
85179 | 1.S | K10.85179 | 1.S | 211.39 | R-RS-Z0.09
85182 | 1.S | K10.85182 | 1.S | 1170 | R-RS-Z0.09
85185 | 1.S | K10.85185 | 1.S | 13567.5 | R-RS-Z0.09
85188 | 1.S | K10.85188 | 1.S | 723.17 | R-RS-Z0.09
85192 | 1.S | K10.85192 | 1.S | 30.72 | R-RS-Z0.09
85193 | 1.S | K10.85193 | 1.S | 354.56 | R-RS-Z0.09
85309 | 1.S | K10.85309 | 1.S | 1734.48 | R-RS-Z0.09
85337 | 1.S | K10.85337 | 1.S | 2450 | R-RS-Z0.09
85416 | 1.S | K10.85416 | 1.S | 1430 | R-RS-Z0.10
85417 | 1.S | K10.85417 | 1.S | 2402.61 | R-RS-Z0.10
85420 | 1.S | K10.85420 | 1.S | 6873.98 | R-RS-Z0.10
85423 | 1.S | K10.85423 | 1.S | 121.39 | R-RS-Z0.10
85426 | 1.S | K10.85426 | 1.S | 1170 | R-RS-Z0.10
85429 | 1.S | K10.85429 | 1.S | 13907 | R-RS-Z0.10
85431 | 1.S | K10.85431 | 1.S | 3230.1 | R-RS-Z0.10
85434 | 1.S | K10.85434 | 1.S | 2450 | R-RS-Z0.10
85438 | 1.S | K10.85438 | 1.S | 2021.84 | R-RS-Z0.10
85442 | 1.S | K10.85442 | 1.S | 105.72 | R-RS-Z0.10
85443 | 1.S | K10.85443 | 1.S | 354.56 | R-RS-Z0.10
85594 | 1.S | K10.85594 | 1.S | 1325 | R-RS-Z0.11
85595 | 1.S | K10.85595 | 1.S | 2192.61 | R-RS-Z0.11
85598 | 1.S | K10.85598 | 1.S | 6678.98 | R-RS-Z0.11
85601 | 1.S | K10.85601 | 1.S | 226.39 | R-RS-Z0.11
85604 | 1.S | K10.85604 | 1.S | 1170 | R-RS-Z0.11
85607 | 1.S | K10.85607 | 1.S | 15610.7 | R-RS-Z0.11
85685 | 1.S | K10.85685 | 1.S | 504.034 | R-RS-Z0.11
85738 | 1.S | K10.85738 | 1.S | 2170 | R-RS-Z0.11
85946 | 1.S | K10.85946 | 1.S | 1445 | R-RS-Z0.12
85947 | 1.S | K10.85947 | 1.S | 2432.61 | R-RS-Z0.12
85950 | 1.S | K10.85950 | 1.S | 6903.98 | R-RS-Z0.12
85953 | 1.S | K10.85953 | 1.S | 106.39 | R-RS-Z0.12
85956 | 1.S | K10.85956 | 1.S | 1170 | R-RS-Z0.12
85959 | 1.S | K10.85959 | 1.S | 13570.6 | R-RS-Z0.12
85962 | 1.S | K10.85962 | 1.S | 3148.05 | R-RS-Z0.12
85963 | 1.S | K10.85963 | 1.S | 980 | R-RS-Z0.12
85966 | 1.S | K10.85966 | 1.S | 2850.04 | R-RS-Z0.12
85973 | 1.S | K10.85973 | 1.S | 530.59 | R-RS-Z0.12
85974 | 1.S | K10.85974 | 1.S | 2350 | R-RS-Z0.12
91453 | 1.S | K10.91453 | 1.S | 1310 | R-RS-Z0.20
91454 | 1.S | K10.91454 | 1.S | 2162.61 | R-RS-Z0.20
91457 | 1.S | K10.91457 | 1.S | 6648.98 | R-RS-Z0.20
91460 | 1.S | K10.91460 | 1.S | 241.39 | R-RS-Z0.20
91463 | 1.S | K10.91463 | 1.S | 1170 | R-RS-Z0.20
91466 | 1.S | K10.91466 | 1.S | 11369.1 | R-RS-Z0.20
91517 | 1.S | K10.91517 | 1.S | 6973.35 | R-RS-Z0.20
91519 | 1.S | K10.91519 | 1.S | 240.72 | R-RS-Z0.20
91520 | 1.S | K10.91520 | 1.S | 354.56 | R-RS-Z0.20
91541 | 1.S | K10.91541 | 1.S | 2450 | R-RS-Z0.20
91546 | 1.S | K10.91546 | 1.S | 1460 | R-RS-Z0.21
91547 | 1.S | K10.91547 | 1.S | 2462.61 | R-RS-Z0.21
91550 | 1.S | K10.91550 | 1.S | 6933.98 | R-RS-Z0.21
91553 | 1.S | K10.91553 | 1.S | 91.39 | R-RS-Z0.21
91556 | 1.S | K10.91556 | 1.S | 870 | R-RS-Z0.21
91559 | 1.S | K10.91559 | 1.S | 11519.1 | R-RS-Z0.21
91560 | 1.S | K10.91560 | 1.S | 6443.98 | R-RS-Z0.21
91561 | 1.S | K10.91561 | 1.S | 255.72 | R-RS-Z0.21
91562 | 1.S | K10.91562 | 1.S | 354.56 | R-RS-Z0.21
91571 | 1.S | K10.91571 | 1.S | 2300 | R-RS-Z0.21
91701 | 5.NP | K10.91701 | 5.NP | 17670 | R-RS-ZTI-4-01
91702 | 1.S | K10.91702 | 1.S | 151.39 | R-RS-ZTI-4-01
91703 | 1.S | K10.91703 | 1.S | 1379.05 | R-RS-ZTI-4-01
91706 | 1.S | K10.91706 | 1.S | 2323.79 | R-RS-ZTI-4-01
91709 | 1.S | K10.91709 | 1.S | 6971.54 | R-RS-ZTI-4-01
91712 | 1.S | K10.91712 | 1.S | 16031.5 | R-RS-ZTI-4-01
91713 | 1.S | K10.91713 | 1.S | 950 | R-RS-ZTI-4-01
91783 | Střecha | K10.91783 | Střecha | 2578.57 | R-RS-ZTI-4-01
91785 | Střecha | K10.91785 | Střecha | 550 | R-RS-ZTI-4-01
91789 | Střecha | K10.91789 | Střecha | 550 | R-RS-ZTI-4-01
91793 | Střecha | K10.91793 | Střecha | 526.31 | R-RS-ZTI-4-01
91796 | Střecha | K10.91796 | Střecha | 32454.2 | R-RS-ZTI-4-01
91822 | 4.NP | K10.91822 | 4.NP | 6160.92 | R-RS-ZTI-4-02
91827 | 4.NP mezipatro | K10.91827 | 4.NP mezipatro | 4049.99 | R-RS-ZTI-4-02
91832 | 4.NP | K10.91832 | 4.NP | 11920 | R-RS-ZTI-4-02
91833 | 1.S | K10.91833 | 1.S | 151.39 | R-RS-ZTI-4-02
91834 | 1.S | K10.91834 | 1.S | 1379.05 | R-RS-ZTI-4-02
91837 | 1.S | K10.91837 | 1.S | 2308.79 | R-RS-ZTI-4-02
91840 | 1.S | K10.91840 | 1.S | 6719.05 | R-RS-ZTI-4-02
91843 | 1.S | K10.91843 | 1.S | 16036.5 | R-RS-ZTI-4-02
91844 | 1.S | K10.91844 | 1.S | 950 | R-RS-ZTI-4-02
91933 | 4.NP mezipatro | K10.91933 | 4.NP mezipatro | 700 | R-RS-ZTI-4-02
91936 | 4.NP mezipatro | K10.91936 | 4.NP mezipatro | 2304.71 | R-RS-ZTI-4-02
91946 | 4.NP | K10.91946 | 4.NP | 664.914 | R-RS-ZTI-4-02
91949 | 4.NP | K10.91949 | 4.NP | 4043.87 | R-RS-ZTI-4-02
91965 | 4.NP mezipatro | K10.91965 | 4.NP mezipatro | 1420 | R-RS-ZTI-4-02
91973 | 4.NP mezipatro | K10.91973 | 4.NP mezipatro | 1618.86 | R-RS-ZTI-4-02
92003 | 4.NP mezipatro | K10.92003 | 4.NP mezipatro | 6030.39 | R-RS-ZTI-4-02
92952 | 4.NP mezipatro | K10.92952 | 4.NP mezipatro | 13400 | R-RS-ZTI-4-03
92953 | 1.S | K10.92953 | 1.S | 151.39 | R-RS-ZTI-4-03
92954 | 1.S | K10.92954 | 1.S | 1379.05 | R-RS-ZTI-4-03
92957 | 1.S | K10.92957 | 1.S | 2353.79 | R-RS-ZTI-4-03
92960 | 1.S | K10.92960 | 1.S | 6764.05 | R-RS-ZTI-4-03
92963 | 1.S | K10.92963 | 1.S | 16081.5 | R-RS-ZTI-4-03
92964 | 1.S | K10.92964 | 1.S | 950 | R-RS-ZTI-4-03
93059 | 4.NP mezipatro | K10.93059 | 4.NP mezipatro | 2589.54 | R-RS-ZTI-4-03
93060 | 4.NP mezipatro | K10.93060 | 4.NP mezipatro | 700 | R-RS-ZTI-4-03
93061 | 4.NP mezipatro | K10.93061 | 4.NP mezipatro | 2349.71 | R-RS-ZTI-4-03
93081 | 4.NP mezipatro | K10.93081 | 4.NP mezipatro | 998.79 | R-RS-ZTI-4-03
200359 | 1.S | K10.200359 | 1.S | 1380 | R-RS-Z0.08
200603 | 1.S | K10.200603 | 1.S | 1400 | R-RS-Z0.12
200750 | 1.S | K10.200750 | 1.S | 230 | R-RS-Z0.12
205081 | 1.S | K10.205081 | 1.S | 270 | R-RS-Z0.21
205241 | 1.S | K10.205241 | 1.S | 1460 | R-RS-Z0.23
205242 | 1.S | K10.205242 | 1.S | 2462.61 | R-RS-Z0.23
205245 | 1.S | K10.205245 | 1.S | 6933.98 | R-RS-Z0.23
205248 | 1.S | K10.205248 | 1.S | 91.39 | R-RS-Z0.23
205251 | 1.S | K10.205251 | 1.S | 870 | R-RS-Z0.23
205252 | 1.S | K10.205252 | 1.S | 7339.05 | R-RS-Z0.23
205253 | 1.S | K10.205253 | 1.S | 6983.68 | R-RS-Z0.23
205254 | 1.S | K10.205254 | 1.S | 255.72 | R-RS-Z0.23
205255 | 1.S | K10.205255 | 1.S | 354.56 | R-RS-Z0.23
205264 | 1.S | K10.205264 | 1.S | 2300 | R-RS-Z0.23
205705 | 1.S | K10.205705 | 1.S | 1460 | R-RS-Z0-CCTV
205706 | 1.S | K10.205706 | 1.S | 2462.61 | R-RS-Z0-CCTV
205709 | 1.S | K10.205709 | 1.S | 6933.98 | R-RS-Z0-CCTV
205712 | 1.S | K10.205712 | 1.S | 91.39 | R-RS-Z0-CCTV
205715 | 1.S | K10.205715 | 1.S | 870 | R-RS-Z0-CCTV
205716 | 1.S | K10.205716 | 1.S | 7583.48 | R-RS-Z0-CCTV
205717 | 1.S | K10.205717 | 1.S | 3758.68 | R-RS-Z0-CCTV
205720 | 1.S | K10.205720 | 1.S | 2300 | R-RS-Z0-CCTV
205723 | 1.S | K10.205723 | 1.S | 180 | R-RS-Z0-CCTV
205987 | 1.S | K10.205987 | 1.S | 1418.05 | R-RS-Z0.24
205988 | 1.S | K10.205988 | 1.S | 2476.57 | R-RS-Z0.24
205991 | 1.S | K10.205991 | 1.S | 7087.03 | R-RS-Z0.24
205994 | 1.S | K10.205994 | 1.S | 68.022 | R-RS-Z0.24
205997 | 1.S | K10.205997 | 1.S | 1170 | R-RS-Z0.24
206000 | 1.S | K10.206000 | 1.S | 7840.59 | R-RS-Z0.24
206003 | 1.S | K10.206003 | 1.S | 34491 | R-RS-Z0.24
206006 | 1.S | K10.206006 | 1.S | 3989.9 | R-RS-Z0.24
206009 | 1.S | K10.206009 | 1.S | 290 | R-RS-Z0.24
206120 | 1.S | K10.206120 | 1.S | 2374.8 | R-RS-Z0.24
206179 | 1.S | K10.206179 | 1.S | 1418.05 | R-RS-Z0.25
206180 | 1.S | K10.206180 | 1.S | 2476.57 | R-RS-Z0.25
206183 | 1.S | K10.206183 | 1.S | 7087.03 | R-RS-Z0.25
206186 | 1.S | K10.206186 | 1.S | 68.022 | R-RS-Z0.25
206189 | 1.S | K10.206189 | 1.S | 1170 | R-RS-Z0.25
206192 | 1.S | K10.206192 | 1.S | 7840.59 | R-RS-Z0.25
206195 | 1.S | K10.206195 | 1.S | 34491 | R-RS-Z0.25
206198 | 1.S | K10.206198 | 1.S | 4167.49 | R-RS-Z0.25
206201 | 1.S | K10.206201 | 1.S | 795.04 | R-RS-Z0.25
206205 | 1.S | K10.206205 | 1.S | 2374.8 | R-RS-Z0.25
206562 | 1.S | K10.206562 | 1.S | 1460 | R-RS-LM-FAS-01
206563 | 1.S | K10.206563 | 1.S | 2462.61 | R-RS-LM-FAS-01
206566 | 1.S | K10.206566 | 1.S | 6953.98 | R-RS-LM-FAS-01
206569 | 1.S | K10.206569 | 1.S | 91.39 | R-RS-LM-FAS-01
206572 | 1.S | K10.206572 | 1.S | 870 | R-RS-LM-FAS-01
206573 | 1.S | K10.206573 | 1.S | 1041.97 | R-RS-LM-FAS-01
206574 | 1.S | K10.206574 | 1.S | 7608.98 | R-RS-LM-FAS-01
206575 | 1.S | K10.206575 | 1.S | 255.72 | R-RS-LM-FAS-01
206576 | 1.S | K10.206576 | 1.S | 354.56 | R-RS-LM-FAS-01
206585 | 1.S | K10.206585 | 1.S | 435 | R-RS-LM-FAS-01
206771 | 1.S | K10.206771 | 1.S | 10087.3 | R-RS-LM-FAS-01
206827 | 1.S | K10.206827 | 1.S | 270 | R-RS-LM-FAS-01
207026 | 1.S | K10.207026 | 1.S | 218.16 | R-RS-Z0.02
207086 | 1.S | K10.207086 | 1.S | 280 | R-RS-Z0.03
207096 | 1.S | K10.207096 | 1.S | 470 | R-RS-Z0.03
230409 | 4.NP | K10.230409 | 4.NP | 5810 | R-RS-ZTI-4-02
230521 | 1.S | K10.230521 | 1.S | 150 | R-RS-Z0.08
232542 | 1.S | K10.232542 | 1.S | 1305 | R-RS-Z5.01
232543 | 1.S | K10.232543 | 1.S | 2152.61 | R-RS-Z5.01
232546 | 1.S | K10.232546 | 1.S | 6638.98 | R-RS-Z5.01
232549 | 1.S | K10.232549 | 1.S | 246.39 | R-RS-Z5.01
232552 | 1.S | K10.232552 | 1.S | 1170 | R-RS-Z5.01
232555 | 1.S | K10.232555 | 1.S | 15955 | R-RS-Z5.01
232561 | 1.S | K10.232561 | 1.S | 14180 | R-RS-Z5.01
232802 | 5.NP | K10.232802 | 5.NP | 165.46 | R-RS-Z5.01
232982 | 5.NP | K10.232982 | 5.NP | 496.015 | R-RS-Z5.01
233074 | 5.NP | K10.233074 | 5.NP | 85.079 | R-RS-Z5.01

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x2,5 + CY16 (9)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x2,5 + CY16; ElementProjectSpecificDescription: CYKY-J 3x2,5 + CY16; ElementProjectSpecificIdentifier: K11; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x2,5 + CY16
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: R-RS-Z0-RACK
Pset_DistributionSystemCommon - Reference: R-RS
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x2,5 + CY16:...) | Reference | Length
205552 | K11.205552 | 1460
205553 | K11.205553 | 2462.61
205556 | K11.205556 | 6933.98
205559 | K11.205559 | 91.39
205562 | K11.205562 | 870
205563 | K11.205563 | 7583.48
205564 | K11.205564 | 3963.68
205575 | K11.205575 | 2300
205685 | K11.205685 | 180

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 3x2,5+CYA6ZŽ (79)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 3x2,5+CYA6ZŽ; ElementProjectSpecificDescription: CYKY-J 3x2,5+CYA6ZŽ; ElementProjectSpecificIdentifier: K12; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 3x2,5+CYA6ZŽ
Pset_DistributionSystemCommon - Reference: R-RS
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 3x2,5+CYA6ZŽ:...) | In | CZ_ElementCommon, Reference | StoreyProjectSpecificIdentifier | Length | Pset_JunctionBoxTypeCommon, Reference
96728 | 4.NP | K12.96728 | 4.NP | 17300 | R-RS-VZT-ACC-05.1
96729 | 1.S | K12.96729 | 1.S | 151.39 | R-RS-VZT-ACC-05.1
96730 | 1.S | K12.96730 | 1.S | 1379.05 | R-RS-VZT-ACC-05.1
96733 | 1.S | K12.96733 | 1.S | 2323.79 | R-RS-VZT-ACC-05.1
96736 | 1.S | K12.96736 | 1.S | 6836.54 | R-RS-VZT-ACC-05.1
96739 | 1.S | K12.96739 | 1.S | 16031.5 | R-RS-VZT-ACC-05.1
96740 | 1.S | K12.96740 | 1.S | 950 | R-RS-VZT-ACC-05.1
96899 | 5.NP mezipatro | K12.96899 | 5.NP mezipatro | 248.71 | R-RS-VZT-ACC-05.1
96902 | 5.NP mezipatro | K12.96902 | 5.NP mezipatro | 2078.55 | R-RS-VZT-ACC-05.1
96907 | 5.NP mezipatro | K12.96907 | 5.NP mezipatro | 1685.13 | R-RS-VZT-ACC-05.1
96911 | 5.NP mezipatro | K12.96911 | 5.NP mezipatro | 1246.16 | R-RS-VZT-ACC-05.1
96915 | 5.NP mezipatro | K12.96915 | 5.NP mezipatro | 2150 | R-RS-VZT-ACC-05.1
97508 | 1.S | K12.97508 | 1.S | 151.39 | R-RS-VZT-ACC-01
97509 | 1.S | K12.97509 | 1.S | 1379.05 | R-RS-VZT-ACC-01
97512 | 1.S | K12.97512 | 1.S | 2323.79 | R-RS-VZT-ACC-01
97515 | 1.S | K12.97515 | 1.S | 7079.05 | R-RS-VZT-ACC-01
97518 | 1.S | K12.97518 | 1.S | 4775.04 | R-RS-VZT-ACC-01
97519 | 1.S | K12.97519 | 1.S | 950 | R-RS-VZT-ACC-01
97699 | 1.S | K12.97699 | 1.S | 1263.88 | R-RS-VZT-ACC-01
97740 | 1.S | K12.97740 | 1.S | 140.72 | R-RS-VZT-ACC-01
97741 | 1.S | K12.97741 | 1.S | 241.42 | R-RS-VZT-ACC-01
97763 | 1.S | K12.97763 | 1.S | 4735.04 | R-RS-VZT-ACC-01
97766 | 1.S | K12.97766 | 1.S | 7039.05 | R-RS-VZT-ACC-01
97769 | 1.S | K12.97769 | 1.S | 2283.79 | R-RS-VZT-ACC-01
97772 | 1.S | K12.97772 | 1.S | 1379.05 | R-RS-VZT-ACC-01
97775 | 1.S | K12.97775 | 1.S | 171.39 | R-RS-VZT-ACC-01
97824 | 1.S | K12.97824 | 1.S | 1243.88 | R-RS-VZT-ACC-01
97865 | 1.S | K12.97865 | 1.S | 140.72 | R-RS-VZT-ACC-01
97866 | 1.S | K12.97866 | 1.S | 241.42 | R-RS-VZT-ACC-01
97888 | 1.S | K12.97888 | 1.S | 950 | R-RS-VZT-ACC-01
97926 | 1.S | K12.97926 | 1.S | 1754.8 | R-RS-VZT-ACC-01
97943 | 1.S | K12.97943 | 1.S | 1754.8 | R-RS-VZT-ACC-01
97975 | 1.S | K12.97975 | 1.S | 191.39 | R-RS-VZT-ACC-01
97978 | 1.S | K12.97978 | 1.S | 1379.05 | R-RS-VZT-ACC-01
97981 | 1.S | K12.97981 | 1.S | 2243.79 | R-RS-VZT-ACC-01
97984 | 1.S | K12.97984 | 1.S | 6999.05 | R-RS-VZT-ACC-01
97987 | 1.S | K12.97987 | 1.S | 2715.04 | R-RS-VZT-ACC-01
98045 | 1.S | K12.98045 | 1.S | 675.041 | R-RS-VZT-ACC-01
98048 | 1.S | K12.98048 | 1.S | 6959.05 | R-RS-VZT-ACC-01
98051 | 1.S | K12.98051 | 1.S | 2203.79 | R-RS-VZT-ACC-01
98054 | 1.S | K12.98054 | 1.S | 1379.05 | R-RS-VZT-ACC-01
98057 | 1.S | K12.98057 | 1.S | 211.39 | R-RS-VZT-ACC-01
98109 | 1.S | K12.98109 | 1.S | 231.39 | R-RS-VZT-ACC-01
98112 | 1.S | K12.98112 | 1.S | 1379.05 | R-RS-VZT-ACC-01
98115 | 1.S | K12.98115 | 1.S | 2163.79 | R-RS-VZT-ACC-01
98118 | 1.S | K12.98118 | 1.S | 6919.05 | R-RS-VZT-ACC-01
98121 | 1.S | K12.98121 | 1.S | 635.041 | R-RS-VZT-ACC-01
98181 | 1.S | K12.98181 | 1.S | 950 | R-RS-VZT-ACC-01
98191 | 1.S | K12.98191 | 1.S | 950 | R-RS-VZT-ACC-01
98199 | 1.S | K12.98199 | 1.S | 950 | R-RS-VZT-ACC-01
98274 | 1.S | K12.98274 | 1.S | 1203.88 | R-RS-VZT-ACC-01
98275 | 1.S | K12.98275 | 1.S | 1183.88 | R-RS-VZT-ACC-01
98277 | 1.S | K12.98277 | 1.S | 1754.8 | R-RS-VZT-ACC-01
98280 | 1.S | K12.98280 | 1.S | 1754.8 | R-RS-VZT-ACC-01
98296 | 1.S | K12.98296 | 1.S | 1223.88 | R-RS-VZT-ACC-01
98298 | 1.S | K12.98298 | 1.S | 1754.8 | R-RS-VZT-ACC-01
98321 | 1.S | K12.98321 | 1.S | 140.72 | R-RS-VZT-ACC-01
98322 | 1.S | K12.98322 | 1.S | 241.42 | R-RS-VZT-ACC-01
98341 | 1.S | K12.98341 | 1.S | 140.72 | R-RS-VZT-ACC-01
98342 | 1.S | K12.98342 | 1.S | 241.42 | R-RS-VZT-ACC-01
98361 | 1.S | K12.98361 | 1.S | 140.72 | R-RS-VZT-ACC-01
98362 | 1.S | K12.98362 | 1.S | 241.42 | R-RS-VZT-ACC-01
233819 | 5.NP mezipatro | K12.233819 | 5.NP mezipatro | 606.16 | R-RS-VZT-ACC-05.1
233866 | 5.NP mezipatro | K12.233866 | 5.NP mezipatro | 1830.13 | R-RS-VZT-ACC-05.1
233891 | 5.NP mezipatro | K12.233891 | 5.NP mezipatro | 449.59 | R-RS-VZT-ACC-05.1
233934 | 5.NP mezipatro | K12.233934 | 5.NP mezipatro | 1850 | R-RS-VZT-ACC-05.1
233968 | 5.NP mezipatro | K12.233968 | 5.NP mezipatro | 400 | R-RS-VZT-ACC-05.1
234082 | 1.S | K12.234082 | 1.S | 17300 | R-RS-VZT-ACC-05.1
234083 | 1.S | K12.234083 | 1.S | 131.39 | R-RS-VZT-ACC-05.1
234084 | 1.S | K12.234084 | 1.S | 1399.05 | R-RS-VZT-ACC-05.1
234087 | 1.S | K12.234087 | 1.S | 2363.79 | R-RS-VZT-ACC-05.1
234090 | 1.S | K12.234090 | 1.S | 6876.54 | R-RS-VZT-ACC-05.1
234093 | 1.S | K12.234093 | 1.S | 16051.5 | R-RS-VZT-ACC-05.1
234094 | 1.S | K12.234094 | 1.S | 950 | R-RS-VZT-ACC-05.1
234101 | 5.NP mezipatro | K12.234101 | 5.NP mezipatro | 268.71 | R-RS-VZT-ACC-05.1
234102 | 5.NP mezipatro | K12.234102 | 5.NP mezipatro | 2078.55 | R-RS-VZT-ACC-05.1
234103 | 5.NP mezipatro | K12.234103 | 5.NP mezipatro | 1645.13 | R-RS-VZT-ACC-05.1
234106 | 5.NP mezipatro | K12.234106 | 5.NP mezipatro | 1226.16 | R-RS-VZT-ACC-05.1
234107 | 5.NP mezipatro | K12.234107 | 5.NP mezipatro | 2150 | R-RS-VZT-ACC-05.1

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 4x10 + CYA25ZŽ (6)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 4x10 + CYA25ZŽ; ElementProjectSpecificDescription: CYKY-J 4x10 + CYA25ZŽ; ElementProjectSpecificIdentifier: K14; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 4x10 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 4x10 + CYA25ZŽ:...) | Reference | Length
115908 | K14.115908 | 1900
115916 | K14.115916 | 1969.81
115932 | K14.115932 | 1480
115940 | K14.115940 | 219.995
115959 | K14.115959 | 1400
115972 | K14.115972 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 4x35 + CYA25ZŽ (4)
In: 1.S
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 4x35 + CYA25ZŽ; ElementProjectSpecificDescription: CYKY-J 4x35 + CYA25ZŽ; ElementProjectSpecificIdentifier: K15; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 4x35 + CYA25ZŽ
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 4x35 + CYA25ZŽ:...) | Reference | Length
116204 | K15.116204 | 1400
116207 | K15.116207 | 1540
116210 | K15.116210 | 2250.42
116213 | K15.116213 | 1400

# IfcCableCarrierSegment: Elektroinstalační trubka bez tvarovek:CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5 (18)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5; ElementProjectSpecificDescription: CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5; ElementProjectSpecificIdentifier: K16; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabel ESI
Type - CZ_CCI - CCI_FunctionalSystemsCode: W; CCI_TechnicalSystemsCode: WD; CCI_ComponentsCode: WDB
Type - Pset_CableSegmentTypeCableSegment - Standard: CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5
Pset_JunctionBoxTypeCommon - Reference: Rozvaděče
Pset_DistributionSystemCommon - Reference: RH
Name (Elektroinstalační trubka bez tvarovek:CYKY-J 4x35+25 + CYA25ZŽ + CYKY-O 7x1,5:...) | In | Reference | StoreyProjectSpecificIdentifier | Length
115576 | 1.S | K16.115576 | 1.S | 1860
115584 | 1.S | K16.115584 | 1.S | 1969.81
115600 | 1.S | K16.115600 | 1.S | 440
115608 | 1.S | K16.115608 | 1.S | 100
115628 | 1.S | K16.115628 | 1.S | 1400
115641 | 1.S | K16.115641 | 1.S | 1400
117091 | 1.S | K16.117091 | 1.S | 151.39
117092 | 1.S | K16.117092 | 1.S | 1379.05
