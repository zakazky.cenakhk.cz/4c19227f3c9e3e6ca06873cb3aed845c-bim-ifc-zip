Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: c90db463-5e02-4672-afa5-c9c10d4bc81c, NumberOfSaves: 133], ExchangeRequirement [BuildingService], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: C:\Users\Petr.Kadera\Downloads\IO-pripojky.ifc
Time: 2025-03-07T12:45:19+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (CSY) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:#Hlavní (2)
Name | LongName | Elevation (mm)
B.p.v | B.p.v | 0
1NP | 1NP | 439500

# IfcSpace: #Ochranné pásmo:#Ochranné pásmo 1m, elektrické vedení (54)
Type - Material: #Manipulační prostor
Type - CZ_ElementCommon - ElementProjectSpecificName: Ochranné pásmo 1m, elektrické vedení; ElementProjectSpecificIdentifier: IO 500, IO 600; ElementProjectSpecificDescription: ochranné pásmo areálových rozvodů elektrického vedení
Type - CZ_DTcommon - DT_name: zóny pro elektrické vedení
Type - CZ_CCI - CCI_BuiltSpacesCode: DCB
CZ_ElementCommon - ElementProjectObjectIdentifier: IO600
Name (#Ochranné pásmo:#Ochranné pásmo 1m, elektrické vedení:...) | Reference
275256 | IO 500, IO 600.275256
275489 | IO 500, IO 600.275489
320503 | IO 500, IO 600.320503
320680 | IO 500, IO 600.320680
321059 | IO 500, IO 600.321059
321535 | IO 500, IO 600.321535
321540 | IO 500, IO 600.321540
321635 | IO 500, IO 600.321635
321716 | IO 500, IO 600.321716
365697 | IO 500, IO 600.365697
365865 | IO 500, IO 600.365865
365981 | IO 500, IO 600.365981
366105 | IO 500, IO 600.366105
367091 | IO 500, IO 600.367091
367182 | IO 500, IO 600.367182
367658 | IO 500, IO 600.367658
368055 | IO 500, IO 600.368055
368202 | IO 500, IO 600.368202
368358 | IO 500, IO 600.368358
369082 | IO 500, IO 600.369082
369210 | IO 500, IO 600.369210
369386 | IO 500, IO 600.369386
369704 | IO 500, IO 600.369704
369888 | IO 500, IO 600.369888
370337 | IO 500, IO 600.370337
371854 | IO 500, IO 600.371854
372704 | IO 500, IO 600.372704
372911 | IO 500, IO 600.372911
373799 | IO 500, IO 600.373799
373998 | IO 500, IO 600.373998
374426 | IO 500, IO 600.374426
374582 | IO 500, IO 600.374582
375330 | IO 500, IO 600.375330
375462 | IO 500, IO 600.375462
375897 | IO 500, IO 600.375897
376001 | IO 500, IO 600.376001
376175 | IO 500, IO 600.376175
376493 | IO 500, IO 600.376493
376910 | IO 500, IO 600.376910
377188 | IO 500, IO 600.377188
377286 | IO 500, IO 600.377286
377557 | IO 500, IO 600.377557
377739 | IO 500, IO 600.377739
377873 | IO 500, IO 600.377873
378020 | IO 500, IO 600.378020
378135 | IO 500, IO 600.378135
378495 | IO 500, IO 600.378495
378612 | IO 500, IO 600.378612
378920 | IO 500, IO 600.378920
379019 | IO 500, IO 600.379019
379569 | IO 500, IO 600.379569
379677 | IO 500, IO 600.379677
379801 | IO 500, IO 600.379801
379902 | IO 500, IO 600.379902

# IfcSpace: #Ochranné pásmo:#Ochranné pásmo 1m, kanalizace (5)
Type - Material: #Manipulační prostor
Type - CZ_ElementCommon - ElementProjectSpecificName: Ochranné pásmo 1m, kanalizace; ElementProjectSpecificIdentifier: IO 400; ElementProjectSpecificDescription: Ochranné pásmo areálových rozvodů kanalizace dešťové, splaškové
Type - CZ_DTcommon - DT_name: zóny pro přípojky kanalizace
Type - CZ_CCI - CCI_BuiltSpacesCode: DCB
CZ_ElementCommon - ElementProjectObjectIdentifier: IO 400
Name (#Ochranné pásmo:#Ochranné pásmo 1m, kanalizace:...) | Reference
273049 | IO 400.273049
273062 | IO 400.273062
273077 | IO 400.273077
273310 | IO 400.273310
273700 | IO 400.273700

# IfcSpace: #Ochranné pásmo:#Ochranné pásmo 1m, plynovod (4)
Type - Material: #Manipulační prostor
Type - CZ_CCI - CCI_BuiltSpacesCode: DCB
Type - CZ_ElementCommon - ElementProjectSpecificName: Ochranné pásmo 1m, plynovod; ElementProjectSpecificIdentifier: OCHR 01; ElementProjectSpecificDescription: Ochranné pásmo plynovodu
Type - CZ_DTcommon - DT_name: zóny pro přípojky plynu
CZ_ElementCommon - ElementProjectObjectIdentifier: IO700
Name (#Ochranné pásmo:#Ochranné pásmo 1m, plynovod:...) | Reference
274141 | OCHR 01.274141
274788 | OCHR 01.274788
315020 | OCHR 01.315020
315482 | OCHR 01.315482

# IfcSpace: #Ochranné pásmo:#Ochranné pásmo 1m, vodovod (2)
Type - Material: #Manipulační prostor
Type - CZ_DTcommon - DT_name: zóny pro připojky vody
Type - CZ_ElementCommon - ElementProjectSpecificName: Ochranné pásmo 1m, vodovod; ElementProjectSpecificIdentifier: OCHR02; ElementProjectSpecificDescription: Ochranné pásmo vodovodu
Type - CZ_CCI - CCI_BuiltSpacesCode: DCB
CZ_ElementCommon - ElementProjectObjectIdentifier: IO300
Name (#Ochranné pásmo:#Ochranné pásmo 1m, vodovod:...) | Reference
266073 | OCHR02.266073
266086 | OCHR02.266086
