Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: c3d9dcb2-fb55-46ed-b06b-26f974195c37, NumberOfSaves: 0], ExchangeRequirement [BuildingService], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: ZDE ZADEJTE ČÍSLO PROJEKTU
Time: 2025-03-07T13:15:18+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (CSY) - IFC 23.3.1.0

# IfcProject, ZDE ZADEJTE ČÍSLO PROJEKTU
LongName: ZDE ZADEJTE NÁZEV PROJEKTU; Phase: ZDE ZADEJTE STUPEŇ PD

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:0,000, 1.S
LongName: 1.S; Elevation: 0 mm

# IfcBuildingStorey: Podlaží:Podlaží (12)
Name | LongName | Elevation (mm)
1.S mezipatro | 1.S mezipatro | 1500
1.NP | 1.NP | 3000
1.NP mezipatro | 1.NP mezipatro | 4500
2.NP | 2.NP | 6000
2.NP mezipatro | 2.NP mezipatro | 7500
3.NP | 3.NP | 9000
3.NP mezipatro | 3.NP mezipatro | 10500
4.NP | 4.NP | 12000
4.NP mezipatro | 4.NP mezipatro | 13500
5.NP | 5.NP | 15000
5.NP mezipatro | 5.NP mezipatro | 16500
Sřecha | Sřecha | 20200

# IfcBuildingElementProxy: Zásobníkový ohřívač vody_10L.CC:Zásobníkový ohřívač vody_10L.CC (2)
In: 1.S
Type - Material: <Unnamed>
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Zásobníkový ohřívač vody_10L.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: průtokové ohřívače VOD; DT_code: VOD.ST.O
Name (Zásobníkový ohřívač vody_10L.CC:Zásobníkový ohřívač vody_10L.CC:...) | Reference | Group
931285 | ZO.136 | Voda_Teplá 1; Voda_Studená 3
960251 | ZO.137 | Voda_Studená 6; Voda_Teplá 4

# IfcCovering: Izolace trubky:i (130)
Type - PredefinedType: INSULATION
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: IZ; ElementProjectSpecificDescription: izolace potrubí
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: RQA
CZ_ElementCommon - ElementProjectSpecificName: i; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: izolace potrubí VOD; DT_code: VOD.RO.I
Name (Izolace trubky:i:...) | In | Reference
962963 | 1.S | IZ.04
962964 | 1.S | IZ.05
962965 | 1.S | IZ.06
962966 | 1.S | IZ.07
962967 | 1.S mezipatro | IZ.08
962968 | 1.S mezipatro | IZ.09
962969 | 1.S mezipatro | IZ.10
962970 | 1.S mezipatro | IZ.11
962971 | 1.S mezipatro | IZ.12
962972 | 1.S mezipatro | IZ.13
962973 | 1.S mezipatro | IZ.14
962974 | 1.S | IZ.15
962975 | 1.S | IZ.16
962976 | 1.S | IZ.17
962977 | 1.S | IZ.18
962978 | 1.S | IZ.19
962979 | 1.S mezipatro | IZ.20
962980 | 1.S mezipatro | IZ.21
962981 | 1.S mezipatro | IZ.22
962982 | 1.S mezipatro | IZ.23
962983 | 1.S mezipatro | IZ.24
962984 | 1.S mezipatro | IZ.25
962985 | 1.S | IZ.26
962986 | 1.S | IZ.27
962987 | 1.S mezipatro | IZ.28
962988 | 1.S | IZ.29
962989 | 1.S | IZ.30
962990 | 1.S | IZ.31
962991 | 1.S | IZ.32
962992 | 1.S mezipatro | IZ.33
962993 | 1.S | IZ.34
962994 | 1.S mezipatro | IZ.35
962995 | 1.S | IZ.36
962996 | 1.S mezipatro | IZ.37
962997 | 1.S | IZ.38
962998 | 1.S mezipatro | IZ.39
962999 | 1.S | IZ.40
963000 | 1.S | IZ.41
963001 | 1.S | IZ.42
963002 | 1.S | IZ.43
963003 | 1.S | IZ.44
963004 | 1.S | IZ.45
963005 | 1.S mezipatro | IZ.46
963006 | 1.S mezipatro | IZ.47
963007 | 1.S mezipatro | IZ.48
963008 | 1.S | IZ.49
963009 | 1.S | IZ.50
963010 | 1.S mezipatro | IZ.51
963011 | 1.S | IZ.52
963012 | 1.S | IZ.53
963013 | 1.S | IZ.54
963014 | 1.S | IZ.55
963015 | 1.S | IZ.56
963016 | 1.S | IZ.57
963017 | 1.S | IZ.58
963018 | 1.S | IZ.59
963019 | 1.S mezipatro | IZ.60
963020 | 1.S | IZ.61
963021 | 1.S | IZ.62
963022 | 1.S mezipatro | IZ.63
963023 | 1.S mezipatro | IZ.64
963024 | 1.S mezipatro | IZ.65
963025 | 1.S mezipatro | IZ.66
963026 | 1.S mezipatro | IZ.67
963027 | 1.S mezipatro | IZ.68
963028 | 1.S mezipatro | IZ.69
963029 | 1.S mezipatro | IZ.70
963030 | 1.S | IZ.71
963031 | 1.S | IZ.72
963032 | 1.S mezipatro | IZ.73
963033 | 1.S | IZ.74
963034 | 1.S | IZ.75
963035 | 1.S | IZ.76
963036 | 1.S mezipatro | IZ.77
963037 | 1.S mezipatro | IZ.78
963038 | 1.S mezipatro | IZ.79
963039 | 1.S mezipatro | IZ.80
963040 | 1.S mezipatro | IZ.81
963041 | 1.S mezipatro | IZ.82
963042 | 1.S mezipatro | IZ.83
963043 | 1.S mezipatro | IZ.84
963044 | 1.S | IZ.85
963045 | 1.S | IZ.86
963046 | 1.S mezipatro | IZ.87
963047 | 1.S | IZ.88
963048 | 1.S | IZ.89
963049 | 1.S | IZ.90
963050 | 1.S mezipatro | IZ.91
963051 | 1.S mezipatro | IZ.92
963052 | 1.S mezipatro | IZ.93
963053 | 1.S mezipatro | IZ.94
963054 | 1.S mezipatro | IZ.95
963055 | 1.S mezipatro | IZ.96
963056 | 1.S mezipatro | IZ.97
963057 | 1.S mezipatro | IZ.98
963058 | 1.S mezipatro | IZ.99
963059 | 1.S mezipatro | IZ.100
963060 | 1.S mezipatro | IZ.101
963061 | 1.S | IZ.102
963062 | 1.S mezipatro | IZ.103
963063 | 1.S | IZ.104
963064 | 1.S | IZ.105
963065 | 1.S | IZ.106
963066 | 1.S | IZ.107
963067 | 1.S | IZ.108
963068 | 1.S | IZ.109
963069 | 1.S | IZ.110
963070 | 1.S | IZ.111
963071 | 1.S | IZ.112
963072 | 1.S | IZ.113
963073 | 1.S | IZ.114
963074 | 1.S | IZ.115
963075 | 1.S | IZ.116
963076 | 1.S | IZ.117
963078 | 1.S | IZ.119
963079 | 1.S | IZ.120
963080 | 1.S | IZ.121
963081 | 1.S | IZ.122
963082 | 1.S | IZ.123
963083 | 1.S | IZ.124
963085 | 1.S | IZ.126
963086 | 1.S | IZ.127
963087 | 1.S | IZ.128
963088 | 1.S | IZ.129
963089 | 1.S | IZ.130
963090 | 1.S | IZ.131
963091 | 1.S | IZ.132
963092 | 1.S | IZ.133
963093 | 1.S | IZ.134
963094 | 1.S | IZ.135

# IfcDistributionPort (288)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection | SystemType | Group
InPort_956601_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_931285_5 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_931285_6 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_955425_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
Port_954596_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 1
Port_954596_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 1
Port_954888_4 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 1
Port_954888_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 1
Port_955018_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 1
Port_955018_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 1
Port_955106_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955106_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955131_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955125_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960134_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955125_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960354_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955131_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960137_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955218_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960354_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955218_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955317_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955315_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955594_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955315_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955317_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955320_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955332_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955320_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956345_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955332_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955551_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_955427_2 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_955415_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
InPort_955415_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_955503_1 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
InPort_955425_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_955427_1 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
InPort_955503_2 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_955501_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
InPort_955501_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_955558_1 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
Port_955551_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956313_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_955558_2 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_957603_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
Port_955563_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955593_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955563_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955815_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955583_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955593_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955583_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955686_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955593_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955594_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955671_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955688_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955671_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955700_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955684_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955686_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955684_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955688_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955692_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955700_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955692_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955733_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 2
Port_955733_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 2
Port_955815_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956313_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955815_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955815_4 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955925_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955909_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956229_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955909_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955925_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956127_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955926_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955929_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955926_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955933_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955929_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956127_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_955933_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956230_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956215_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956229_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956215_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956266_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956229_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956230_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956233_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956266_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956233_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956266_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956277_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956277_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956337_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956345_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956337_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956452_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956439_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956454_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956439_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956491_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956450_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956452_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956450_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956454_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956489_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956491_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956489_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956493_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956493_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956520_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_956520_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_956591_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_956603_2 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957177_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_956591_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_956603_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_956601_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_956608_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957179_2 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957191_2 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_956608_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957175_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957177_2 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957179_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957175_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957183_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957191_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957199_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957183_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957193_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957199_2 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957381_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 1
OutPort_957193_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 1
Port_957201_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957381_3 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957201_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957249_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957241_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957249_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957241_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957302_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957289_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957304_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957289_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957314_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957300_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957302_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957300_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957304_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957314_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957316_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957316_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957381_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957392_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957392_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957412_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957402_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957412_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957402_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957420_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957414_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957420_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957414_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957447_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957439_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957447_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957439_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957480_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957463_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957482_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957463_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957515_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957478_0 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957480_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957478_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957482_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957515_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957517_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
Port_957517_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 1
InPort_957603_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_957702_1 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
InPort_957702_2 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
OutPort_957662_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 3
InPort_957662_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 3
Port_957831_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 2
Port_957831_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 2
Port_957843_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 4
Port_957843_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 4
InPort_957852_1 | SINK | DOMESTICHOTWATER
InPort_957852_2 | SINK | DOMESTICCOLDWATER
Port_957940_1 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 3
Port_957940_2 | SOURCEANDSINK | DOMESTICHOTWATER | Voda_Teplá 3
Port_957941_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 5
Port_957941_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 5
InPort_957942_1 | SINK | DOMESTICHOTWATER
InPort_957942_2 | SINK | DOMESTICCOLDWATER
Port_960134_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960137_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_962832_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_960251_5 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_960251_6 | SINK | DOMESTICCOLDWATER | Voda_Studená 6
OutPort_961213_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 6
Port_960354_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960458_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960367_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960458_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960367_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960389_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960381_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960389_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960381_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960397_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960397_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960933_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960933_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960937_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960934_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960937_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_960934_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961058_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961052_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961058_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961052_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961070_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961062_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961070_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961062_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961080_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961080_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961431_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_961213_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 6
OutPort_961251_1 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 6
Port_961243_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962555_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961243_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961267_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_961251_2 | SINK | DOMESTICCOLDWATER | Voda_Studená 6
OutPort_962556_0 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 6
Port_961255_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961267_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961255_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961434_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961403_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961452_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961403_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961434_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961431_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_961452_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_962479_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962770_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962479_2 | SINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962526_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962559_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962526_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962563_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962553_0 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962555_3 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962553_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962559_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_962556_1 | SINK | DOMESTICCOLDWATER | Voda_Studená 6
OutPort_962555_2 | SOURCE | DOMESTICCOLDWATER | Voda_Studená 6
Port_962563_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
Port_962928_1 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6
InPort_962770_2 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962802_2 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962800_0 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962800_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962804_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962802_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962804_2 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962808_0 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962808_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962838_2 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962820_0 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962834_2 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962838_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962820_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
InPort_962834_1 | SINK | DOMESTICHOTWATER | Voda_Teplá 4
OutPort_962832_1 | SOURCE | DOMESTICHOTWATER | Voda_Teplá 4
Port_962928_2 | SOURCEANDSINK | DOMESTICCOLDWATER | Voda_Studená 6

# IfcDistributionSystem: Voda_Studená (6)
PredefinedType: DOMESTICCOLDWATER
Name
Voda_Studená 3
Voda_Studená 1
Voda_Studená 6
Voda_Studená 2
Voda_Studená 4
Voda_Studená 5

# IfcDistributionSystem: Voda_Teplá (4)
PredefinedType: DOMESTICHOTWATER
Name
Voda_Teplá 1
Voda_Teplá 2
Voda_Teplá 3
Voda_Teplá 4

# IfcFlowTerminal: Baterie stojánková.CC:Baterie stojánková.CC (2)
In: 1.S
Type - Material: NEREZOVÁ OCEL
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: U; ElementProjectSpecificDescription: Baterie stojánková.CC, Baterie stojánková.CC
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Baterie stojánková.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: VOD.KP.P
Name (Baterie stojánková.CC:Baterie stojánková.CC:...) | Reference
957852 | U.01
957942 | U.02

# IfcFlowTerminal: Invalida_Baterie_ nástěnná.CC:Invalida_Baterie_ nástěnná.CC, Invalida_Baterie_ nástěnná.CC:Invalida_Baterie_ nástěnná.CC:962479
In: 1.S
Type - Material: NEREZOVÁ OCEL
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VYL; ElementProjectSpecificDescription: Baterie
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Invalida_Baterie_ nástěnná.CC; ElementProjectObjectIdentifier: SO 01; Reference: VYL.03; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: zařizovací předměty KAN; DT_code: VOD.KP.P
Group: Voda_Studená 6; Voda_Teplá 4

# IfcPipeFitting: HDPE_Elektrokoleno 90.CC:HDPE_Elektrokoleno 90.CC, HDPE_Elektrokoleno 90.CC:HDPE_Elektrokoleno 90.CC:954888
In: 1.S
Type - Material: Trubky_HDPE
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Elektrokoleno 90°
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: HDPE_Elektrokoleno 90.CC; ElementProjectObjectIdentifier: SO 01; Reference: TR.209; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: tvarovky VOD; DT_code: VOD.TV.T
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Voda_Studená 1

# IfcPipeFitting: PP-R_Koleno PN16.CC:PP-R_Koleno PN16.CC (47)
In: 1.S
Type - Material: Trubky_PP R PN16
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Koleno
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: PP-R_Koleno PN16.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: tvarovky VOD; DT_code: VOD.TV.T
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (PP-R_Koleno PN16.CC:PP-R_Koleno PN16.CC:...) | Reference | Group
955131 | TR.211 | Voda_Studená 6
955315 | TR.212 | Voda_Studená 6
955332 | TR.213 | Voda_Studená 6
955427 | TR.214 | Voda_Studená 3
955503 | TR.215 | Voda_Studená 3
955558 | TR.216 | Voda_Studená 3
955686 | TR.217 | Voda_Studená 6
955688 | TR.218 | Voda_Studená 6
955700 | TR.219 | Voda_Studená 6
955929 | TR.220 | Voda_Studená 6
955933 | TR.221 | Voda_Studená 6
956345 | TR.222 | Voda_Studená 6
956452 | TR.223 | Voda_Studená 6
956454 | TR.224 | Voda_Studená 6
956491 | TR.225 | Voda_Studená 6
956493 | TR.226 | Voda_Studená 6
956603 | TR.227 | Voda_Teplá 1
957177 | TR.228 | Voda_Teplá 1
957179 | TR.229 | Voda_Teplá 1
957191 | TR.230 | Voda_Teplá 1
957199 | TR.231 | Voda_Teplá 1
957249 | TR.232 | Voda_Teplá 1
957302 | TR.233 | Voda_Teplá 1
957304 | TR.234 | Voda_Teplá 1
957314 | TR.235 | Voda_Teplá 1
957412 | TR.236 | Voda_Teplá 1
957420 | TR.237 | Voda_Teplá 1
957447 | TR.238 | Voda_Teplá 1
957480 | TR.239 | Voda_Teplá 1
957482 | TR.240 | Voda_Teplá 1
957515 | TR.241 | Voda_Teplá 1
960389 | TR.242 | Voda_Studená 6
960397 | TR.243 | Voda_Studená 6
960937 | TR.244 | Voda_Studená 6
961058 | TR.245 | Voda_Studená 6
961070 | TR.246 | Voda_Studená 6
961080 | TR.247 | Voda_Studená 6
961251 | TR.248 | Voda_Studená 6
961267 | TR.249 | Voda_Studená 6
961434 | TR.250 | Voda_Studená 6
961452 | TR.251 | Voda_Studená 6
962559 | TR.252 | Voda_Studená 6
962563 | TR.253 | Voda_Studená 6
962802 | TR.254 | Voda_Teplá 4
962804 | TR.255 | Voda_Teplá 4
962834 | TR.256 | Voda_Teplá 4
962838 | TR.257 | Voda_Teplá 4

# IfcPipeFitting: PP-R_Křížení PN16.CC:PP-R_Křížení PN16.CC, PP-R_Křížení PN16.CC:PP-R_Křížení PN16.CC:955815
In: 1.S
Type - Material: Trubky_PP R PN16
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Křížení
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: PP-R_Křížení PN16.CC; ElementProjectObjectIdentifier: SO 01; Reference: TR.258; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: tvarovky VOD; DT_code: VOD.TV.T
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Voda_Studená 6

# IfcPipeFitting: PP-R_Odbočka PN16.CC:PP-R_Odbočka PN16.CC (6)
In: 1.S
Type - Material: Trubky_PP R PN16
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Odbočka
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: PP-R_Odbočka PN16.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: tvarovky VOD; DT_code: VOD.TV.T
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (PP-R_Odbočka PN16.CC:PP-R_Odbočka PN16.CC:...) | Reference | Group
955593 | TR.259 | Voda_Studená 6
956229 | TR.260 | Voda_Studená 6
956266 | TR.261 | Voda_Studená 6
957381 | TR.262 | Voda_Teplá 1
960354 | TR.263 | Voda_Studená 6
962555 | TR.264 | Voda_Studená 6

# IfcPipeFitting: PP-R_Redukce PN16.CC:PP-R_Redukce PN16.CC (11)
In: 1.S
Type - Material: Trubky_PP R PN16
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Redukce
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: PP-R_Redukce PN16.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: tvarovky VOD; DT_code: VOD.TV.T
Name (PP-R_Redukce PN16.CC:PP-R_Redukce PN16.CC:...) | Reference | Length (mm) | Group
955317 | TR.265 | 62.5 | Voda_Studená 6
955733 | TR.266 | 34 | Voda_Studená 2
956127 | TR.267 | 39.5 | Voda_Studená 6
956313 | TR.268 | 39.5 | Voda_Studená 6
956520 | TR.269 | 34 | Voda_Studená 6
957316 | TR.270 | 34 | Voda_Teplá 1
957517 | TR.271 | 34 | Voda_Teplá 1
957702 | TR.272 | 39.5 | Voda_Studená 3
960458 | TR.273 | 49.3 | Voda_Studená 6
962770 | TR.274 | 34 | Voda_Teplá 4
962928 | TR.275 | 34 | Voda_Studená 6

# IfcPipeSegment: Typy trubek:Plast - HDPE 100 (2)
In: 1.S
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Trubka
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Plast - HDPE 100; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: potrubí VOD; DT_code: VOD.RO.P
Group: Voda_Studená 1
Name (Typy trubek:Plast - HDPE 100:...) | Reference | Length (mm)
954596 | TR.143 | 1976
955018 | TR.144 | 952

# IfcPipeSegment: Typy trubek:Voda PP PN16 (62)
In: 1.S
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: TR; ElementProjectSpecificDescription: Trubka
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Voda PP PN16; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: potrubí VOD; DT_code: VOD.RO.P
Name (Typy trubek:Voda PP PN16:...) | Reference | Length (mm) | Group
955106 | TR.145 | 2531.9 | Voda_Studená 6
955125 | TR.146 | 13830.1 | Voda_Studená 6
955218 | TR.147 | 845.902 | Voda_Studená 6
955320 | TR.148 | 1091.25 | Voda_Studená 6
955415 | TR.149 | 45.4 | Voda_Studená 3
955425 | TR.150 | 237.7 | Voda_Studená 3
955501 | TR.151 | 1380.4 | Voda_Studená 3
955551 | TR.152 | 1500.89 | Voda_Studená 6
955563 | TR.153 | 1945.56 | Voda_Studená 6
955583 | TR.154 | 935.235 | Voda_Studená 6
955594 | TR.155 | 624.156 | Voda_Studená 6
955671 | TR.156 | 312.447 | Voda_Studená 6
955684 | TR.157 | 1995.4 | Voda_Studená 6
955692 | TR.158 | 7.7 | Voda_Studená 6
955909 | TR.159 | 259.879 | Voda_Studená 6
955925 | TR.160 | 19.4654 | Voda_Studená 6
955926 | TR.161 | 1475.4 | Voda_Studená 6
956215 | TR.162 | 181 | Voda_Studená 6
956230 | TR.163 | 13.6036 | Voda_Studená 6
956233 | TR.164 | 100 | Voda_Studená 6
956277 | TR.165 | 610 | Voda_Studená 6
956337 | TR.166 | 138.515 | Voda_Studená 6
956439 | TR.167 | 551.103 | Voda_Studená 6
956450 | TR.168 | 2125.4 | Voda_Studená 6
956489 | TR.169 | 55.4 | Voda_Studená 6
956591 | TR.170 | 95.4 | Voda_Teplá 1
956601 | TR.171 | 237.7 | Voda_Teplá 1
956608 | TR.172 | 230.4 | Voda_Teplá 1
957175 | TR.173 | 1330.4 | Voda_Teplá 1
957183 | TR.174 | 145.4 | Voda_Teplá 1
957193 | TR.175 | 70.7 | Voda_Teplá 1
957201 | TR.176 | 520.7 | Voda_Teplá 1
957241 | TR.177 | 995.743 | Voda_Teplá 1
957289 | TR.178 | 695.409 | Voda_Teplá 1
957300 | TR.179 | 1950.4 | Voda_Teplá 1
957392 | TR.180 | 48.5182 | Voda_Teplá 1
957402 | TR.181 | 1605.4 | Voda_Teplá 1
957414 | TR.182 | 1112.03 | Voda_Teplá 1
957439 | TR.183 | 209.204 | Voda_Teplá 1
957463 | TR.184 | 353.409 | Voda_Teplá 1
957478 | TR.185 | 1950.4 | Voda_Teplá 1
957603 | TR.186 | 471.364 | Voda_Studená 3
957662 | TR.187 | 71.8415 | Voda_Studená 3
960137 | TR.188 | 201.311 | Voda_Studená 6
960367 | TR.189 | 920.981 | Voda_Studená 6
960381 | TR.190 | 4543.07 | Voda_Studená 6
960933 | TR.191 | 145.83 | Voda_Studená 6
960934 | TR.192 | 1416.93 | Voda_Studená 6
961052 | TR.193 | 245.4 | Voda_Studená 6
961062 | TR.194 | 1130.57 | Voda_Studená 6
961213 | TR.195 | 37.7 | Voda_Studená 6
961243 | TR.196 | 56.8844 | Voda_Studená 6
961255 | TR.197 | 233.873 | Voda_Studená 6
961403 | TR.198 | 488.589 | Voda_Studená 6
961431 | TR.199 | 4081.62 | Voda_Studená 6
962526 | TR.201 | 198.985 | Voda_Studená 6
962553 | TR.202 | 30.7 | Voda_Studená 6
962556 | TR.203 | 44.5156 | Voda_Studená 6
962800 | TR.205 | 75.4 | Voda_Teplá 4
962808 | TR.206 | 448.985 | Voda_Teplá 4
962820 | TR.207 | 39.2156 | Voda_Teplá 4
962832 | TR.208 | 87.7 | Voda_Teplá 4

# IfcValve: Roháček.CC:Roháček.CC (4)
In: 1.S
Type - Material: NEREZOVÁ OCEL
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: ARM; ElementProjectSpecificDescription: Roháček.CC, Roháček.CC
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: Roháček.CC; ElementProjectObjectIdentifier: SO 01; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: potrubí VOD; DT_code: VOD.RO.P
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Name (Roháček.CC:Roháček.CC:...) | Reference | Group
957831 | ARM.139 | Voda_Teplá 2
957843 | ARM.140 | Voda_Studená 4
957940 | ARM.141 | Voda_Teplá 3
957941 | ARM.142 | Voda_Studená 5

# IfcValve: Závitový_Kulový kohout.CC:DN10, Závitový_Kulový kohout.CC:DN10:960134
In: 1.S
Type - Material: MANIPULAČNÍ PROSTOR, <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificIdentifier: VEN; ElementProjectSpecificDescription: Ventil
Type - Qto_PipeSegmentBaseQuantities - Length: 45 mm
CZ_CCI - CCI_FunctionalSystemsCode: F; CCI_TechnicalSystemsCode: JB; CCI_ComponentsCode: WPA
CZ_ElementCommon - ElementProjectSpecificName: DN10; ElementProjectObjectIdentifier: SO 01; Reference: VEN.138; StoreyProjectSpecificIdentifier: 1.S
CZ_DTcommon - DT_name: armatury a ventily VOD; DT_code: VOD.PP.A
Qto_PipeSegmentBaseQuantities - Length: 1 mm
Group: Voda_Studená 6
