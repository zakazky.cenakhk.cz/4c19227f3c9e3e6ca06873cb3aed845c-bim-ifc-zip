Properties of the parts of a building model (IFC4), part 2 of 2

# IfcCableCarrierSegment: Elektroinstalační trubka s tvarovkami:Pevná elektroinstalační trubka (RNC, výkaz 40) (366)
Name (Elektroinstalační trubka s tvarovkami:Pevná elektroinstalační trubka (RNC, výkaz 40):...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1839050 | 3.NP mezipatro | TK.1839050 | Kabel T5 | 3.NP mezipatro
1839057 | 3.NP mezipatro | TK.1839057 | Kabel T5 | 3.NP mezipatro
1839066 | 3.NP mezipatro | TK.1839066 | Kabel T5 | 3.NP mezipatro
1839073 | 3.NP mezipatro | TK.1839073 | Kabel T5 | 3.NP mezipatro
1839082 | 3.NP mezipatro | TK.1839082 | Kabel T5 | 3.NP mezipatro
1839089 | 3.NP mezipatro | TK.1839089 | Kabel T5 | 3.NP mezipatro
1839217 | 3.NP mezipatro | TK.1839217 | Kabel T5 | 3.NP mezipatro
1840123 | 3.NP mezipatro | TK.1840123 | Kabel T5 | 3.NP mezipatro
1840234 | 3.NP mezipatro | TK.1840234 | Kabel T5 | 3.NP mezipatro
1840288 | 3.NP mezipatro | TK.1840288 | Kabel T5 | 3.NP mezipatro
1840491 | 3.NP mezipatro | TK.1840491 | Kabel T5 | 3.NP mezipatro
1841466 | 2.NP mezipatro | TK.1841466 | Kabel T4 | 2.NP mezipatro
1841473 | 2.NP mezipatro | TK.1841473 | Kabel T4 | 2.NP mezipatro
1841480 | 2.NP mezipatro | TK.1841480 | Kabel T4 | 2.NP mezipatro
1841489 | 2.NP mezipatro | TK.1841489 | Kabel T4 | 2.NP mezipatro
1841496 | 2.NP mezipatro | TK.1841496 | Kabel T4 | 2.NP mezipatro
1841505 | 2.NP mezipatro | TK.1841505 | Kabel T4 | 2.NP mezipatro
1841528 | 2.NP mezipatro | TK.1841528 | Kabel T4 | 2.NP mezipatro
1841535 | 2.NP mezipatro | TK.1841535 | Kabel T4 | 2.NP mezipatro
1841542 | 2.NP mezipatro | TK.1841542 | Kabel T4 | 2.NP mezipatro
1841551 | 2.NP mezipatro | TK.1841551 | Kabel T4 | 2.NP mezipatro
1841558 | 2.NP mezipatro | TK.1841558 | Kabel T4 | 2.NP mezipatro
1841567 | 2.NP mezipatro | TK.1841567 | Kabel T4 | 2.NP mezipatro
1841574 | 2.NP mezipatro | TK.1841574 | Kabel T4 | 2.NP mezipatro
1841583 | 2.NP mezipatro | TK.1841583 | Kabel T4 | 2.NP mezipatro
1841590 | 2.NP mezipatro | TK.1841590 | Kabel T4 | 2.NP mezipatro
1841599 | 2.NP mezipatro | TK.1841599 | Kabel T4 | 2.NP mezipatro
1841606 | 2.NP mezipatro | TK.1841606 | Kabel T4 | 2.NP mezipatro
1841615 | 2.NP mezipatro | TK.1841615 | Kabel T4 | 2.NP mezipatro
1841622 | 2.NP mezipatro | TK.1841622 | Kabel T4 | 2.NP mezipatro
1841631 | 2.NP mezipatro | TK.1841631 | Kabel T4 | 2.NP mezipatro
1841638 | 2.NP mezipatro | TK.1841638 | Kabel T4 | 2.NP mezipatro
1841645 | 2.NP mezipatro | TK.1841645 | Kabel T4 | 2.NP mezipatro
1841654 | 2.NP mezipatro | TK.1841654 | Kabel T4 | 2.NP mezipatro
1841661 | 2.NP mezipatro | TK.1841661 | Kabel T4 | 2.NP mezipatro
1841670 | 2.NP mezipatro | TK.1841670 | Kabel T4 | 2.NP mezipatro
1841677 | 2.NP mezipatro | TK.1841677 | Kabel T4 | 2.NP mezipatro
1841686 | 2.NP mezipatro | TK.1841686 | Kabel T4 | 2.NP mezipatro
1841693 | 2.NP mezipatro | TK.1841693 | Kabel T4 | 2.NP mezipatro
1841702 | 2.NP mezipatro | TK.1841702 | Kabel T4 | 2.NP mezipatro
1841709 | 2.NP mezipatro | TK.1841709 | Kabel T4 | 2.NP mezipatro
1841724 | 2.NP mezipatro | TK.1841724 | Kabel T4 | 2.NP mezipatro
1841792 | 2.NP mezipatro | TK.1841792 | Kabel T4 | 2.NP mezipatro
1841866 | 2.NP mezipatro | TK.1841866 | Kabel T4 | 2.NP mezipatro
1841935 | 2.NP mezipatro | TK.1841935 | Kabel T4 | 2.NP mezipatro
1842596 | 4.NP mezipatro | TK.1842596 | Kabel T6 | 4.NP mezipatro
1842603 | 4.NP mezipatro | TK.1842603 | Kabel T6 | 4.NP mezipatro
1842610 | 4.NP mezipatro | TK.1842610 | Kabel T6 | 4.NP mezipatro
1842619 | 4.NP mezipatro | TK.1842619 | Kabel T6 | 4.NP mezipatro
1842626 | 4.NP mezipatro | TK.1842626 | Kabel T6 | 4.NP mezipatro
1842635 | 4.NP mezipatro | TK.1842635 | Kabel T6 | 4.NP mezipatro
1843147 | 4.NP mezipatro | TK.1843147 | Kabel T6 | 4.NP mezipatro
1843154 | 4.NP mezipatro | TK.1843154 | Kabel T6 | 4.NP mezipatro
1843163 | 4.NP mezipatro | TK.1843163 | Kabel T6 | 4.NP mezipatro
1843172 | 4.NP mezipatro | TK.1843172 | Kabel T6 | 4.NP mezipatro
1843179 | 4.NP mezipatro | TK.1843179 | Kabel T6 | 4.NP mezipatro
1843188 | 4.NP mezipatro | TK.1843188 | Kabel T6 | 4.NP mezipatro
1843195 | 4.NP mezipatro | TK.1843195 | Kabel T6 | 4.NP mezipatro
1843207 | 4.NP mezipatro | TK.1843207 | Kabel T6 | 4.NP mezipatro
1843214 | 4.NP mezipatro | TK.1843214 | Kabel T6 | 4.NP mezipatro
1843225 | 4.NP mezipatro | TK.1843225 | Kabel T6 | 4.NP mezipatro
1843232 | 4.NP mezipatro | TK.1843232 | Kabel T6 | 4.NP mezipatro
1843241 | 4.NP mezipatro | TK.1843241 | Kabel T6 | 4.NP mezipatro
1843248 | 4.NP mezipatro | TK.1843248 | Kabel T6 | 4.NP mezipatro
1843260 | 4.NP mezipatro | TK.1843260 | Kabel T6 | 4.NP mezipatro
1843267 | 4.NP mezipatro | TK.1843267 | Kabel T6 | 4.NP mezipatro
1843274 | 4.NP mezipatro | TK.1843274 | Kabel T6 | 4.NP mezipatro
1843283 | 4.NP mezipatro | TK.1843283 | Kabel T6 | 4.NP mezipatro
1843290 | 4.NP mezipatro | TK.1843290 | Kabel T6 | 4.NP mezipatro
1843299 | 4.NP mezipatro | TK.1843299 | Kabel T6 | 4.NP mezipatro
1843306 | 4.NP mezipatro | TK.1843306 | Kabel T6 | 4.NP mezipatro
1843315 | 4.NP mezipatro | TK.1843315 | Kabel T6 | 4.NP mezipatro
1843322 | 4.NP mezipatro | TK.1843322 | Kabel T6 | 4.NP mezipatro
1843331 | 4.NP mezipatro | TK.1843331 | Kabel T6 | 4.NP mezipatro
1843338 | 4.NP mezipatro | TK.1843338 | Kabel T6 | 4.NP mezipatro
1843353 | 4.NP mezipatro | TK.1843353 | Kabel T6 | 4.NP mezipatro
1843398 | 4.NP mezipatro | TK.1843398 | Kabel T6 | 4.NP mezipatro
1843462 | 4.NP mezipatro | TK.1843462 | Kabel T6 | 4.NP mezipatro
1843529 | 4.NP mezipatro | TK.1843529 | Kabel T6 | 4.NP mezipatro
1843885 | 5.NP | TK.1843885 | Kabel T6 | 5.NP
1843892 | 5.NP | TK.1843892 | Kabel T6 | 5.NP
1843896 | 5.NP | TK.1843896 | Kabel T6 | 5.NP
1843903 | 5.NP | TK.1843903 | Kabel T6 | 5.NP
1843912 | 5.NP | TK.1843912 | Kabel T6 | 5.NP
1843919 | 5.NP | TK.1843919 | Kabel T6 | 5.NP
1843928 | 5.NP | TK.1843928 | Kabel T6 | 5.NP
1843930 | 5.NP | TK.1843930 | Kabel T6 | 5.NP
1843937 | 5.NP | TK.1843937 | Kabel T6 | 5.NP
1843946 | 5.NP | TK.1843946 | Kabel T6 | 5.NP
1843948 | 5.NP | TK.1843948 | Kabel T6 | 5.NP
1843955 | 5.NP | TK.1843955 | Kabel T6 | 5.NP
1843964 | 5.NP | TK.1843964 | Kabel T6 | 5.NP
1843966 | 5.NP | TK.1843966 | Kabel T6 | 5.NP
1843973 | 5.NP | TK.1843973 | Kabel T6 | 5.NP
1843982 | 5.NP | TK.1843982 | Kabel T6 | 5.NP
1843984 | 5.NP | TK.1843984 | Kabel T6 | 5.NP
1843991 | 5.NP | TK.1843991 | Kabel T6 | 5.NP
1844000 | 5.NP | TK.1844000 | Kabel T6 | 5.NP
1844002 | 5.NP | TK.1844002 | Kabel T6 | 5.NP
1844009 | 5.NP | TK.1844009 | Kabel T6 | 5.NP
1844018 | 5.NP | TK.1844018 | Kabel T6 | 5.NP
1844020 | 5.NP | TK.1844020 | Kabel T6 | 5.NP
1844027 | 5.NP | TK.1844027 | Kabel T6 | 5.NP
1844036 | 5.NP | TK.1844036 | Kabel T6 | 5.NP
1844038 | 5.NP | TK.1844038 | Kabel T6 | 5.NP
1844045 | 5.NP | TK.1844045 | Kabel T6 | 5.NP
1844054 | 5.NP | TK.1844054 | Kabel T6 | 5.NP
1844056 | 5.NP | TK.1844056 | Kabel T6 | 5.NP
1844063 | 5.NP | TK.1844063 | Kabel T6 | 5.NP
1844072 | 5.NP | TK.1844072 | Kabel T6 | 5.NP
1844079 | 5.NP | TK.1844079 | Kabel T6 | 5.NP
1844088 | 5.NP | TK.1844088 | Kabel T6 | 5.NP
1844381 | 1.S | TK.1844381 | Kabel T1 | 1.S
1844388 | 1.S | TK.1844388 | Kabel T1 | 1.S
1844428 | 1.S | TK.1844428 | Kabel T1 | 1.S
1844435 | 1.S | TK.1844435 | Kabel T1 | 1.S
1844444 | 1.S | TK.1844444 | Kabel T1 | 1.S
1844451 | 1.S | TK.1844451 | Kabel T1 | 1.S
1844460 | 1.S | TK.1844460 | Kabel T1 | 1.S
1844467 | 1.S | TK.1844467 | Kabel T1 | 1.S
1844476 | 1.S | TK.1844476 | Kabel T1 | 1.S
1844483 | 1.S | TK.1844483 | Kabel T1 | 1.S
1844492 | 1.S | TK.1844492 | Kabel T1 | 1.S
1844499 | 1.S | TK.1844499 | Kabel T1 | 1.S
1844508 | 1.S | TK.1844508 | Kabel T1 | 1.S
1844515 | 1.S | TK.1844515 | Kabel T1 | 1.S
1844522 | 1.S | TK.1844522 | Kabel T1 | 1.S
1844531 | 1.S | TK.1844531 | Kabel T1 | 1.S
1844538 | 1.S | TK.1844538 | Kabel T1 | 1.S
1844547 | 1.S | TK.1844547 | Kabel T1 | 1.S
1844554 | 1.S | TK.1844554 | Kabel T1 | 1.S
1844563 | 1.S | TK.1844563 | Kabel T1 | 1.S
1844570 | 1.S | TK.1844570 | Kabel T1 | 1.S
1844579 | 1.S | TK.1844579 | Kabel T1 | 1.S
1844586 | 1.S | TK.1844586 | Kabel T1 | 1.S
1844595 | 1.S | TK.1844595 | Kabel T1 | 1.S
1844602 | 1.S | TK.1844602 | Kabel T1 | 1.S
1844611 | 1.S | TK.1844611 | Kabel T1 | 1.S
1844620 | 1.S | TK.1844620 | Kabel T1 | 1.S
1844639 | 1.S | TK.1844639 | Kabel T1 | 1.S
1844853 | 1.S | TK.1844853 | Kabel T1 | 1.S
1845100 | 1.S | TK.1845100 | Kabel T1 | 1.S
1845473 | 1.S | TK.1845473 | Kabel T1 | 1.S
1929085 | 1.S | TK.1929085 | Kabel T1 | 1.S

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Kabelová lávka s pevným dnem (6)
In: 1.S
Type - PredefinedType: CABLETRAYSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Kabelová lávka s pevným dnem; ElementProjectSpecificDescription: kabelová lávka požárně odolná; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificIdentifier: Žlab
Type - CZ_DTcommon - DT_name: kabelové lávky a trasy EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (Kabelová lávka s tvarovkami:Kabelová lávka s pevným dnem:...) | Reference | Length
1718470 | Žlab.1718470 | 2745 | CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
1718474 | Žlab.1718474 | 8734.94 | CZ_ElementCommon - ElementProjectSpecificIdentifier: x1
2016491 | Žlab.2016491 | 348.58
2033253 | Žlab.2033253 | 288.75
2033723 | Žlab.2033723 | 71.26
2033733 | Žlab.2033733 | 329.55

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Žebříková kabelová lávka, Kabelová lávka s tvarovkami:Žebříková kabelová lávka:1718522
In: 1.S
Type - PredefinedType: CABLETRAYSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Žebříková kabelová lávka; ElementProjectSpecificDescription: kabelová lávka požárně odolná; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové lávky a trasy EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - Reference: Žebřík.1718522; ElementProjectSpecificIdentifier: x1; StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 17203.6

# IfcDistributionPort (1464)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLECARRIER; SystemType: CONVEYING
Name
Port_1718470_0
Port_1718470_1
Port_2033457_2
Port_1718474_0
Port_2033458_2
Port_1718474_1
Port_2033775_1
Port_1718474_6
Port_2044572_0
Port_1718474_7
Port_2044632_1
Port_1718474_8
Port_2044648_0
Port_1718474_9
Port_2044686_1
Port_1718522_0
Port_1718522_1
Port_1829047_0
Port_1829047_1
Port_1829059_2
Port_1829054_0
Port_1829059_1
Port_1829054_1
Port_1829069_1
Port_1829062_0
Port_1829069_2
Port_1829062_1
Port_1829076_1
Port_1829071_0
Port_1829076_2
Port_1829071_1
Port_1829085_1
Port_1829078_0
Port_1829085_2
Port_1829078_1
Port_1829092_2
Port_1829087_0
Port_1829092_1
Port_1829087_1
Port_1830103_1
Port_1829103_0
Port_1829103_1
Port_1830105_2
Port_1829111_0
Port_1829111_1
Port_1829123_2
Port_1829118_0
Port_1829123_1
Port_1829118_1
Port_1829132_2
Port_1829125_0
Port_1829132_1
Port_1829125_1
Port_1829139_1
Port_1829134_0
Port_1829139_2
Port_1829134_1
Port_1829148_2
Port_1829141_0
Port_1829148_1
Port_1829141_1
Port_1829155_2
Port_1829150_0
Port_1829155_1
Port_1829150_1
Port_1829164_2
Port_1829157_0
Port_1829164_1
Port_1829157_1
Port_1829171_1
Port_1829166_0
Port_1829171_2
Port_1829166_1
Port_1829180_1
Port_1829173_0
Port_1829180_2
Port_1829173_1
Port_1829187_2
Port_1829182_0
Port_1829187_1
Port_1829182_1
Port_1829196_2
Port_1829189_0
Port_1829196_1
Port_1829189_1
Port_1829203_1
Port_1829198_0
Port_1829203_2
Port_1829198_1
Port_1829212_2
Port_1829205_0
Port_1829212_1
Port_1829205_1
Port_1829222_2
Port_1829215_0
Port_1829222_1
Port_1829215_1
Port_1829229_1
Port_1829224_0
Port_1829229_2
Port_1829224_1
Port_1829238_1
Port_1829231_0
Port_1829238_2
Port_1829231_1
Port_1829245_2
Port_1829240_0
Port_1829245_1
Port_1829240_1
Port_1829254_2
Port_1829247_0
Port_1829254_1
Port_1829247_1
Port_1829261_1
Port_1829256_0
Port_1829261_2
Port_1829256_1
Port_1829270_1
Port_1829263_0
Port_1829270_2
Port_1829263_1
Port_1829277_2
Port_1829272_0
Port_1829277_1
Port_1829272_1
Port_1829286_2
Port_1829279_0
Port_1829286_1
Port_1829279_1
Port_1829293_2
Port_1829288_0
Port_1829293_1
Port_1829288_1
Port_1830065_1
Port_1829304_0
Port_1829304_1
Port_1830067_2
Port_1829312_0
Port_1830067_1
Port_1829312_1
Port_1831059_1
Port_1829969_0
Port_1830105_1
Port_1829969_1
Port_1831056_2
Port_1830065_2
Port_1830080_0
Port_1830080_1
Port_1830103_2
Port_1830118_0
Port_1830118_1
Port_1830448_0
Port_1830448_1
Port_1830469_0
Port_1830469_1
Port_1831047_0
Port_1831056_1
Port_1831047_1
Port_1831059_2
Port_1831358_0
Port_1831358_1
Port_1831370_1
Port_1831365_0
Port_1831370_2
Port_1831365_1
Port_1831381_2
Port_1831372_0
Port_1831381_1
Port_1831372_1
Port_1831388_2
Port_1831383_0
Port_1831388_1
Port_1831383_1
Port_1831397_2
Port_1831390_0
Port_1831397_1
Port_1831390_1
Port_1831404_1
Port_1831399_0
Port_1831404_2
Port_1831399_1
Port_1831413_1
Port_1831406_0
Port_1831413_2
Port_1831406_1
Port_1831420_2
Port_1831415_0
Port_1831420_1
Port_1831415_1
Port_1831429_2
Port_1831422_0
Port_1831429_1
Port_1831422_1
Port_1831436_1
Port_1831431_0
Port_1831436_2
Port_1831431_1
Port_1831445_1
Port_1831438_0
Port_1831445_2
Port_1831438_1
Port_1831452_2
Port_1831447_0
Port_1831452_1
Port_1831447_1
Port_1831461_2
Port_1831454_0
Port_1831461_1
Port_1831454_1
Port_1831468_1
Port_1831463_0
Port_1831468_2
Port_1831463_1
Port_1831477_1
Port_1831470_0
Port_1831477_2
Port_1831470_1
Port_1831486_2
Port_1831479_0
Port_1831486_1
Port_1831479_1
Port_1831494_2
Port_1831489_0
Port_1831494_1
Port_1831489_1
Port_1831504_1
Port_1831497_0
Port_1831504_2
Port_1831497_1
Port_1831511_2
Port_1831506_0
Port_1831511_1
Port_1831506_1
Port_1831520_2
Port_1831513_0
Port_1831520_1
Port_1831513_1
Port_1831527_1
Port_1831522_0
Port_1831527_2
Port_1831522_1
Port_1831536_1
Port_1831529_0
Port_1831536_2
Port_1831529_1
Port_1831543_2
Port_1831538_0
Port_1831543_1
Port_1831538_1
Port_1831552_2
Port_1831545_0
Port_1831552_1
Port_1831545_1
Port_1831559_2
Port_1831554_0
Port_1831559_1
Port_1831554_1
Port_1831568_1
Port_1831561_0
Port_1831568_2
Port_1831561_1
Port_1831575_2
Port_1831570_0
Port_1831575_1
Port_1831570_1
Port_1831584_2
Port_1831577_0
Port_1831584_1
Port_1831577_1
Port_1831591_1
Port_1831586_0
Port_1831591_2
Port_1831586_1
Port_1832357_1
Port_1831921_0
Port_1832362_1
Port_1831921_1
Port_1832346_0
Port_1832357_2
Port_1832346_1
Port_1832362_2
Port_1832534_0
Port_1832534_1
Port_1832546_2
Port_1832541_0
Port_1832546_1
Port_1832541_1
Port_1832555_1
Port_1832548_0
Port_1832555_2
Port_1832548_1
Port_1832562_1
Port_1832557_0
Port_1832562_2
Port_1832557_1
Port_1832571_1
Port_1832564_0
Port_1832571_2
Port_1832564_1
Port_1832578_2
Port_1832573_0
Port_1832578_1
Port_1832573_1
Port_1833493_1
Port_1832643_0
Port_1832643_1
Port_2042048_2
Port_1832650_0
Port_2042048_1
Port_1832650_1
Port_2042050_2
Port_1832657_0
Port_2037999_1
Port_1832657_1
Port_2042050_1
Port_1832666_0
Port_2037999_2
Port_1832666_1
Port_1832680_2
Port_1832673_0
Port_1832680_1
Port_1832673_1
Port_1832687_2
Port_1832682_0
Port_1832687_1
Port_1832682_1
Port_1832696_2
Port_1832689_0
Port_1832696_1
Port_1832689_1
Port_1832703_1
Port_1832698_0
Port_1832703_2
Port_1832698_1
Port_1832712_1
Port_1832705_0
Port_1832712_2
Port_1832705_1
Port_1832719_2
Port_1832714_0
Port_1832719_1
Port_1832714_1
Port_1832728_2
Port_1832721_0
Port_1832728_1
Port_1832721_1
Port_1832735_1
Port_1832730_0
Port_1832735_2
Port_1832730_1
Port_1832744_2
Port_1832737_0
Port_1832744_1
Port_1832737_1
Port_1832756_2
Port_1832747_0
Port_1832756_1
Port_1832747_1
Port_1832764_1
Port_1832759_0
Port_1832764_2
Port_1832759_1
Port_1832773_1
Port_1832766_0
Port_1832773_2
Port_1832766_1
Port_1832780_2
Port_1832775_0
Port_1832780_1
Port_1832775_1
Port_1832789_2
Port_1832782_0
Port_1832789_1
Port_1832782_1
Port_1832796_1
Port_1832791_0
Port_1832796_2
Port_1832791_1
Port_1832805_1
Port_1832798_0
Port_1832805_2
Port_1832798_1
Port_1832812_2
Port_1832807_0
Port_1832812_1
Port_1832807_1
Port_1832821_2
Port_1832814_0
Port_1832821_1
Port_1832814_1
Port_1832828_2
Port_1832823_0
Port_1832828_1
Port_1832823_1
Port_1833621_1
Port_1832839_0
Port_1832839_1
Port_1833623_2
Port_1832960_0
Port_1833623_1
Port_1832960_1
Port_2043208_1
Port_1833343_0
Port_1833507_1
Port_1833343_1
Port_2043193_2
Port_1833488_0
Port_1833493_2
Port_1833488_1
Port_1833513_1
Port_1833497_0
Port_1833497_1
Port_1833513_2
Port_1833507_2
Port_1833516_0
Port_1833516_1
Port_1833621_2
Port_1833634_0
Port_1833634_1
Port_1835401_0
Port_1835401_1
Port_1835420_1
Port_1835408_0
Port_1835420_2
Port_1835408_1
Port_1835429_2
Port_1835422_0
Port_1835429_1
Port_1835422_1
Port_1835436_2
Port_1835431_0
Port_1835436_1
Port_1835431_1
Port_1835445_2
Port_1835438_0
Port_1835445_1
Port_1835438_1
Port_1835452_1
Port_1835447_0
Port_1835452_2
Port_1835447_1
Port_1835461_1
Port_1835454_0
Port_1835461_2
Port_1835454_1
Port_1835468_2
Port_1835463_0
Port_1835468_1
Port_1835463_1
Port_1835477_2
Port_1835470_0
Port_1835477_1
Port_1835470_1
Port_1835484_1
Port_1835479_0
Port_1835484_2
Port_1835479_1
Port_1835493_1
Port_1835486_0
Port_1835493_2
Port_1835486_1
Port_1835500_2
Port_1835495_0
Port_1835500_1
Port_1835495_1
Port_1835509_2
Port_1835502_0
Port_1835509_1
Port_1835502_1
Port_1835516_1
Port_1835511_0
Port_1835516_2
Port_1835511_1
Port_1835525_1
Port_1835518_0
Port_1835525_2
Port_1835518_1
Port_1835534_2
Port_1835527_0
Port_1835534_1
Port_1835527_1
Port_1835544_2
Port_1835536_0
Port_1835544_1
Port_1835536_1
Port_1835553_1
Port_1835546_0
Port_1835553_2
Port_1835546_1
Port_1835560_2
Port_1835555_0
Port_1835560_1
Port_1835555_1
Port_1835569_2
Port_1835562_0
Port_1835569_1
Port_1835562_1
Port_1835576_1
Port_1835571_0
Port_1835576_2
Port_1835571_1
Port_1835585_1
Port_1835578_0
Port_1835585_2
Port_1835578_1
Port_1835592_2
Port_1835587_0
Port_1835592_1
Port_1835587_1
Port_1835601_2
Port_1835594_0
Port_1835601_1
Port_1835594_1
Port_1835608_2
Port_1835603_0
Port_1835608_1
Port_1835603_1
Port_1835617_1
Port_1835610_0
Port_1835617_2
Port_1835610_1
Port_1835624_2
Port_1835619_0
Port_1835624_1
Port_1835619_1
Port_1835633_2
Port_1835633_1
Port_1835635_0
Port_1835635_1
Port_1835659_1
Port_1835654_0
Port_1835659_2
Port_1835654_1
Port_1836533_1
Port_1835670_0
Port_1836530_1
Port_1835670_1
Port_1836518_0
Port_1836530_2
Port_1836518_1
Port_1836533_2
Port_1837518_0
Port_1837518_1
Port_1837530_1
Port_1837525_0
Port_1837530_2
Port_1837525_1
Port_1837539_2
Port_1837532_0
Port_1837539_1
Port_1837532_1
Port_1837546_2
Port_1837541_0
Port_1837546_1
Port_1837541_1
Port_1837555_2
Port_1837548_0
Port_1837555_1
Port_1837548_1
Port_1837562_1
Port_1837557_0
Port_1837562_2
Port_1837557_1
Port_1837571_1
Port_1837564_0
Port_1837571_2
Port_1837564_1
Port_1837578_2
Port_1837573_0
Port_1837578_1
Port_1837573_1
Port_1837587_2
Port_1837580_0
Port_1837587_1
Port_1837580_1
Port_1837594_1
Port_1837589_0
Port_1837594_2
Port_1837589_1
Port_1837603_1
Port_1837596_0
Port_1837603_2
Port_1837596_1
Port_1837610_2
Port_1837605_0
Port_1837610_1
Port_1837605_1
Port_1837619_2
Port_1837612_0
Port_1837619_1
Port_1837612_1
Port_1837626_1
Port_1837621_0
Port_1837626_2
Port_1837621_1
Port_1837635_1
Port_1837628_0
Port_1837635_2
Port_1837628_1
Port_1837642_2
Port_1837637_0
Port_1837642_1
Port_1837637_1
Port_1837649_2
Port_1837644_0
Port_1837649_1
Port_1837644_1
Port_1837658_1
Port_1837651_0
Port_1837658_2
Port_1837651_1
Port_1837665_2
Port_1837660_0
Port_1837665_1
Port_1837660_1
Port_1837674_2
Port_1837667_0
Port_1837674_1
Port_1837667_1
Port_1837681_1
Port_1837676_0
Port_1837681_2
Port_1837676_1
Port_1837690_1
Port_1837683_0
Port_1837690_2
Port_1837683_1
Port_1837697_2
Port_1837692_0
Port_1837697_1
Port_1837692_1
Port_1837706_2
Port_1837699_0
Port_1837706_1
Port_1837699_1
Port_1837713_2
Port_1837708_0
Port_1837713_1
Port_1837708_1
Port_1837722_1
Port_1837715_0
Port_1837722_2
Port_1837715_1
Port_1837729_2
Port_1837724_0
Port_1837729_1
Port_1837724_1
Port_1837738_2
Port_1837738_1
Port_1837740_0
Port_1837740_1
Port_1837755_1
Port_1837750_0
Port_1837755_2
Port_1837750_1
Port_1837916_1
Port_1837772_0
Port_1837913_1
Port_1837772_1
Port_1837903_0
Port_1837913_2
Port_1837903_1
Port_1837916_2
Port_1838282_0
Port_1838282_1
Port_1838294_1
Port_1838289_0
Port_1838294_2
Port_1838289_1
Port_1838303_2
Port_1838296_0
Port_1838303_1
Port_1838296_1
Port_1838310_2
Port_1838305_0
Port_1838310_1
Port_1838305_1
Port_1838319_2
Port_1838312_0
Port_1838319_1
Port_1838312_1
Port_1838326_1
Port_1838321_0
Port_1838326_2
Port_1838321_1
Port_1838335_1
Port_1838328_0
Port_1838335_2
Port_1838328_1
Port_1838342_2
Port_1838337_0
Port_1838342_1
Port_1838337_1
Port_1838351_2
Port_1838344_0
Port_1838351_1
Port_1838344_1
Port_1838358_1
Port_1838353_0
Port_1838358_2
Port_1838353_1
Port_1838367_1
Port_1838360_0
Port_1838367_2
Port_1838360_1
Port_1838374_2
Port_1838369_0
Port_1838374_1
Port_1838369_1
Port_1838383_2
Port_1838376_0
Port_1838383_1
Port_1838376_1
Port_1838390_1
Port_1838385_0
Port_1838390_2
Port_1838385_1
Port_1838399_1
Port_1838392_0
Port_1838399_2
Port_1838392_1
Port_1838406_2
Port_1838401_0
Port_1838406_1
Port_1838401_1
Port_1838413_2
Port_1838408_0
Port_1838413_1
Port_1838408_1
Port_1838422_1
Port_1838415_0
Port_1838422_2
Port_1838415_1
Port_1838429_2
Port_1838424_0
Port_1838429_1
Port_1838424_1
Port_1838438_2
Port_1838431_0
Port_1838438_1
Port_1838431_1
Port_1838445_1
Port_1838440_0
Port_1838445_2
Port_1838440_1
Port_1838454_1
Port_1838447_0
Port_1838454_2
Port_1838447_1
Port_1838461_2
Port_1838456_0
Port_1838461_1
Port_1838456_1
Port_1838470_2
Port_1838463_0
Port_1838470_1
Port_1838463_1
Port_1838477_2
Port_1838472_0
Port_1838477_1
Port_1838472_1
Port_1838486_1
Port_1838479_0
Port_1838486_2
Port_1838479_1
Port_1838493_2
Port_1838488_0
Port_1838493_1
Port_1838488_1
Port_1838502_2
Port_1838502_1
Port_1838504_0
Port_1838504_1
Port_1838514_1
Port_1838509_0
Port_1838514_2
Port_1838509_1
Port_1838776_1
Port_1838531_0
Port_1838778_2
Port_1838531_1
Port_1838720_0
Port_1838776_2
Port_1838720_1
Port_1838778_1
Port_1838837_0
Port_1838837_1
Port_1838849_2
Port_1838844_0
Port_1838849_1
Port_1838844_1
Port_1838858_1
Port_1838851_0
Port_1838858_2
Port_1838851_1
Port_1838865_1
Port_1838860_0
Port_1838865_2
Port_1838860_1
Port_1838874_1
Port_1838867_0
Port_1838874_2
Port_1838867_1
Port_1838881_2
Port_1838876_0
Port_1838881_1
Port_1838876_1
Port_1838890_1
Port_1838890_2
Port_1840123_0
Port_1838902_0
Port_1838902_1
Port_1838916_2
Port_1838909_0
Port_1838916_1
Port_1838909_1
Port_1838925_2
Port_1838918_0
Port_1838925_1
Port_1838918_1
Port_1838932_1
Port_1838927_0
Port_1838932_2
Port_1838927_1
Port_1838941_2
Port_1838934_0
Port_1838941_1
Port_1838934_1
Port_1838948_2
Port_1838943_0
Port_1838948_1
Port_1838943_1
Port_1838957_2
Port_1838950_0
Port_1838957_1
Port_1838950_1
Port_1838964_1
Port_1838959_0
Port_1838964_2
Port_1838959_1
Port_1838973_1
Port_1838966_0
Port_1838973_2
Port_1838966_1
Port_1838980_2
Port_1838975_0
Port_1838980_1
Port_1838975_1
Port_1838989_2
Port_1838982_0
Port_1838989_1
Port_1838982_1
Port_1838998_1
Port_1838991_0
Port_1838998_2
Port_1838991_1
Port_1839007_2
Port_1839000_0
Port_1839007_1
Port_1839000_1
Port_1839016_2
Port_1839009_0
Port_1839016_1
Port_1839009_1
Port_1839023_1
Port_1839018_0
Port_1839023_2
Port_1839018_1
Port_1839032_1
Port_1839025_0
Port_1839032_2
Port_1839025_1
Port_1839039_2
Port_1839034_0
Port_1839039_1
Port_1839034_1
Port_1839048_2
Port_1839041_0
Port_1839048_1
Port_1839041_1
Port_1839055_1
Port_1839050_0
Port_1839055_2
Port_1839050_1
Port_1839064_1
Port_1839057_0
Port_1839064_2
Port_1839057_1
Port_1839071_2
Port_1839066_0
Port_1839071_1
Port_1839066_1
Port_1839080_2
Port_1839073_0
Port_1839080_1
Port_1839073_1
Port_1839087_2
Port_1839082_0
Port_1839087_1
Port_1839082_1
Port_1840275_1
Port_1839089_0
Port_1839089_1
Port_1840277_2
Port_1839217_0
Port_1840182_2
Port_1839217_1
Port_1840504_2
Port_1840123_1
Port_1840182_1
Port_1840234_0
Port_1840277_1
Port_1840234_1
Port_1840507_1
Port_1840275_2
Port_1840288_0
Port_1840288_1
Port_1840491_0
Port_1840504_1
Port_1840491_1
Port_1840507_2
Port_1841466_0
Port_1841466_1
Port_1841478_2
Port_1841473_0
Port_1841478_1
Port_1841473_1
Port_1841487_1
Port_1841480_0
Port_1841487_2
Port_1841480_1
Port_1841494_1
Port_1841489_0
Port_1841494_2
Port_1841489_1
Port_1841503_1
Port_1841496_0
Port_1841503_2
Port_1841496_1
Port_1841510_2
Port_1841505_0
Port_1841510_1
Port_1841505_1
Port_1841803_1
Port_1841528_0
Port_1841528_1
Port_1841540_2
Port_1841535_0
Port_1841540_1
Port_1841535_1
Port_1841549_2
Port_1841542_0
Port_1841549_1
Port_1841542_1
Port_1841556_1
Port_1841551_0
Port_1841556_2
Port_1841551_1
Port_1841565_2
Port_1841558_0
Port_1841565_1
Port_1841558_1
Port_1841572_2
Port_1841567_0
Port_1841572_1
Port_1841567_1
Port_1841581_2
Port_1841574_0
Port_1841581_1
Port_1841574_1
Port_1841588_1
Port_1841583_0
Port_1841588_2
Port_1841583_1
Port_1841597_1
Port_1841590_0
Port_1841597_2
Port_1841590_1
Port_1841604_2
Port_1841599_0
Port_1841604_1
Port_1841599_1
Port_1841613_2
Port_1841606_0
Port_1841613_1
Port_1841606_1
Port_1841620_1
Port_1841615_0
Port_1841620_2
Port_1841615_1
Port_1841629_2
Port_1841622_0
Port_1841629_1
Port_1841622_1
Port_1841636_2
Port_1841631_0
Port_1841636_1
Port_1841631_1
Port_1841643_1
Port_1841638_0
Port_1841643_2
Port_1841638_1
Port_1841652_1
Port_1841645_0
Port_1841652_2
Port_1841645_1
Port_1841659_2
Port_1841654_0
Port_1841659_1
Port_1841654_1
Port_1841668_2
Port_1841661_0
Port_1841668_1
Port_1841661_1
Port_1841675_1
Port_1841670_0
Port_1841675_2
Port_1841670_1
Port_1841684_1
Port_1841677_0
Port_1841684_2
Port_1841677_1
Port_1841691_2
Port_1841686_0
Port_1841691_1
Port_1841686_1
Port_1841700_2
Port_1841693_0
Port_1841700_1
Port_1841693_1
Port_1841707_2
Port_1841702_0
Port_1841707_1
Port_1841702_1
Port_1841902_1
Port_1841709_0
Port_1841902_2
Port_1841709_1
Port_1841904_2
Port_1841724_0
Port_1841799_1
Port_1841724_1
Port_1841948_2
Port_1841792_0
Port_1841799_2
Port_1841792_1
Port_1841803_2
Port_1841866_0
Port_1841904_1
Port_1841866_1
Port_1841951_1
Port_1841935_0
Port_1841948_1
Port_1841935_1
Port_1841951_2
Port_1842596_0
Port_1842596_1
Port_1842608_2
Port_1842603_0
Port_1842608_1
Port_1842603_1
Port_1842617_1
Port_1842610_0
Port_1842617_2
Port_1842610_1
Port_1842624_1
Port_1842619_0
Port_1842624_2
Port_1842619_1
Port_1842633_1
Port_1842626_0
Port_1842633_2
Port_1842626_1
Port_1842640_2
Port_1842635_0
Port_1842640_1
Port_1842635_1
Port_1843410_1
Port_1843147_0
Port_1843147_1
Port_1843161_2
Port_1843154_0
Port_1843161_1
Port_1843154_1
Port_1843170_2
Port_1843163_0
Port_1843170_1
Port_1843163_1
Port_1843177_1
Port_1843172_0
Port_1843177_2
Port_1843172_1
Port_1843186_2
Port_1843179_0
Port_1843186_1
Port_1843179_1
Port_1843193_2
Port_1843188_0
Port_1843193_1
Port_1843188_1
Port_1843205_2
Port_1843195_0
Port_1843205_1
Port_1843195_1
Port_1843212_1
Port_1843207_0
Port_1843212_2
Port_1843207_1
Port_1843223_1
Port_1843214_0
Port_1843223_2
Port_1843214_1
Port_1843230_2
Port_1843225_0
Port_1843230_1
Port_1843225_1
Port_1843239_2
Port_1843232_0
Port_1843239_1
Port_1843232_1
Port_1843246_1
Port_1843241_0
Port_1843246_2
Port_1843241_1
Port_1843258_2
Port_1843248_0
Port_1843258_1
Port_1843248_1
Port_1843265_2
Port_1843260_0
Port_1843265_1
Port_1843260_1
Port_1843272_1
Port_1843267_0
Port_1843272_2
Port_1843267_1
Port_1843281_1
Port_1843274_0
Port_1843281_2
Port_1843274_1
Port_1843288_2
Port_1843283_0
Port_1843288_1
Port_1843283_1
Port_1843297_2
Port_1843290_0
Port_1843297_1
Port_1843290_1
Port_1843304_1
Port_1843299_0
Port_1843304_2
Port_1843299_1
Port_1843313_1
Port_1843306_0
Port_1843313_2
Port_1843306_1
Port_1843320_2
Port_1843315_0
Port_1843320_1
Port_1843315_1
Port_1843329_2
Port_1843322_0
Port_1843329_1
Port_1843322_1
Port_1843336_2
Port_1843331_0
Port_1843336_1
Port_1843331_1
Port_1843501_1
Port_1843338_0
Port_1843501_2
Port_1843338_1
Port_1843503_2
Port_1843353_0
Port_1843407_1
Port_1843353_1
Port_1843543_2
Port_1843398_0
Port_1843407_2
Port_1843398_1
Port_1843410_2
Port_1843462_0
Port_1843503_1
Port_1843462_1
Port_1843546_1
Port_1843529_0
Port_1843543_1
Port_1843529_1
Port_1843546_2
Port_1843885_0
Port_1843885_1
Port_1843901_2
Port_1843892_0
Port_1843892_1
Port_1843896_0
Port_1843901_1
Port_1843896_1
Port_1843910_1
Port_1843903_0
Port_1843910_2
Port_1843903_1
Port_1843917_2
Port_1843912_0
Port_1843917_1
Port_1843912_1
Port_1843926_2
Port_1843919_0
Port_1843919_1
Port_1843935_1
Port_1843926_1
Port_1843928_0
Port_1843928_1
Port_1843930_0
Port_1843935_2
Port_1843930_1
Port_1843944_1
Port_1843937_0
Port_1843937_1
Port_1843953_2
Port_1843944_2
Port_1843946_0
Port_1843946_1
Port_1843948_0
Port_1843953_1
Port_1843948_1
Port_1843962_2
Port_1843955_0
Port_1843955_1
Port_1843971_1
Port_1843962_1
Port_1843964_0
Port_1843964_1
Port_1843966_0
Port_1843971_2
Port_1843966_1
Port_1843980_1
Port_1843973_0
Port_1843973_1
Port_1843989_2
Port_1843980_2
Port_1843982_0
Port_1843982_1
Port_1843984_0
Port_1843989_1
Port_1843984_1
Port_1843998_2
Port_1843991_0
Port_1843991_1
Port_1844007_1
Port_1843998_1
Port_1844000_0
Port_1844000_1
Port_1844002_0
Port_1844007_2
Port_1844002_1
Port_1844016_1
Port_1844009_0
Port_1844009_1
Port_1844025_2
Port_1844016_2
Port_1844018_0
Port_1844018_1
Port_1844020_0
Port_1844025_1
Port_1844020_1
Port_1844034_2
Port_1844027_0
Port_1844027_1
Port_1844043_1
Port_1844034_1
Port_1844036_0
Port_1844036_1
Port_1844038_0
Port_1844043_2
Port_1844038_1
Port_1844052_1
Port_1844045_0
Port_1844045_1
Port_1844061_2
Port_1844052_2
Port_1844054_0
Port_1844054_1
Port_1844056_0
Port_1844061_1
Port_1844056_1
Port_1844070_2
Port_1844063_0
Port_1844070_1
Port_1844063_1
Port_1844077_1
Port_1844072_0
Port_1844077_2
Port_1844072_1
Port_1844086_2
Port_1844079_0
Port_1844079_1
Port_1844086_1
Port_1844088_0
Port_1844088_1
Port_1844381_0
Port_1844381_1
Port_2044680_2
Port_1844388_0
Port_1844388_1
Port_1844408_1
Port_2044648_1
Port_1844408_2
Port_1844415_1
Port_1844415_2
Port_2044572_1
Port_1844428_0
Port_1929100_1
Port_1844428_1
Port_1844442_1
Port_1844435_0
Port_1844442_2
Port_1844435_1
Port_1844449_2
Port_1844444_0
Port_1844449_1
Port_1844444_1
Port_1844458_2
Port_1844451_0
Port_1844458_1
Port_1844451_1
Port_1844465_1
Port_1844460_0
Port_1844465_2
Port_1844460_1
Port_1844474_1
Port_1844467_0
Port_1844474_2
Port_1844467_1
Port_1844476_0
Port_1844481_1
Port_1844476_1
Port_1844490_2
Port_1844481_2
Port_1844483_0
Port_1844490_1
Port_1844483_1
Port_1844497_1
Port_1844492_0
Port_1844497_2
Port_1844492_1
Port_1844506_1
Port_1844499_0
Port_1844506_2
Port_1844499_1
Port_1844513_2
Port_1844508_0
Port_1844513_1
Port_1844508_1
Port_1844520_2
Port_1844515_0
Port_1844520_1
Port_1844515_1
Port_1844529_1
Port_1844522_0
Port_1844529_2
Port_1844522_1
Port_1844536_2
Port_1844531_0
Port_1844536_1
Port_1844531_1
Port_1844545_2
Port_1844538_0
Port_1844545_1
Port_1844538_1
Port_1844552_1
Port_1844547_0
Port_1844552_2
Port_1844547_1
Port_1844561_1
Port_1844554_0
Port_1844561_2
Port_1844554_1
Port_1844568_2
Port_1844563_0
Port_1844568_1
Port_1844563_1
Port_1844577_2
Port_1844570_0
Port_1844577_1
Port_1844570_1
Port_1844584_2
Port_1844579_0
Port_1844584_1
Port_1844579_1
Port_1844593_1
Port_1844586_0
Port_1844593_2
Port_1844586_1
Port_1844600_2
Port_1844595_0
Port_1844600_1
Port_1844595_1
Port_1844609_2
Port_1844602_0
Port_1844609_1
Port_1844602_1
Port_1844618_1
Port_1844611_0
Port_1844618_2
Port_1844611_1
Port_1844842_1
Port_1844620_0
Port_1844620_1
Port_1844915_1
Port_1844639_0
Port_1844915_2
Port_1844639_1
Port_1844842_2
Port_1844853_0
Port_1844853_1
Port_1845100_0
Port_1845100_1
Port_1845473_0
Port_1845473_1
Port_1929085_0
Port_2044626_2
Port_1929085_1
Port_1929100_2
Port_2016491_0
Port_2033731_2
Port_2016491_1
Port_2033253_0
Port_2033775_2
Port_2033253_1
Port_2033778_2
Port_2033457_1
Port_2033458_1
Port_2033723_0
Port_2033731_1
Port_2033723_1
Port_2033737_1
Port_2033733_0
Port_2033737_2
Port_2033733_1
Port_2033778_1
Port_2043177_0
Port_2043214_2
Port_2043177_1
Port_2043219_2
Port_2043189_0
Port_2043193_1
Port_2043189_1
Port_2043196_1
Port_2043190_0
Port_2043196_2
Port_2043190_1
Port_2043219_1
Port_2043204_0
Port_2043208_2
Port_2043204_1
Port_2043211_1
Port_2043205_0
Port_2043211_2
Port_2043205_1
Port_2043214_1
Port_2044626_1
Port_2044632_0
Port_2044680_1
Port_2044686_0

# IfcElectricAppliance: Rack NZS 800x800.0001:45U, Rack NZS 800x800.0001:45U:1935492
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: 45U; ElementProjectSpecificDescription: -
CZ_ElementCommon - ElementProjectSpecificIdentifier: 10
