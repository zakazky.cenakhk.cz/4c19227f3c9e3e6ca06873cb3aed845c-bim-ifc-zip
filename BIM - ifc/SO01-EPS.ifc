Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 5477e9bc-0a01-471e-8855-b3dc3ff44aa1, NumberOfSaves: 102]
File name: C:\Users\Petr.Kadera\Downloads\SO01-EPS.ifc
Time: 2025-04-17T14:54:18+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (CSY) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:#Hlavní (12)
Name | LongName | Elevation (mm)
1.S | 1.S | 0
1.S mezipatro | 1.S mezipatro | 1500
1.NP | 1.NP | 3000
1.NP mezipatro | 1.NP mezipatro | 4500
2.NP | 2.NP | 6000
2.NP mezipatro | 2.NP mezipatro | 7500
3.NP | 3.NP | 9000
3.NP mezipatro | 3.NP mezipatro | 10500
4.NP | 4.NP | 12000
4.NP mezipatro | 4.NP mezipatro | 13500
5.NP | 5.NP | 15000
5.NP mezipatro | 5.NP mezipatro | 16500

# IfcAlarm: EPS - tablo:EPS - tablo, EPS - tablo:EPS - tablo:1719972
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: EPS - tablo; ElementProjectSpecificDescription: Tablo EPS
CZ_ElementCommon - ElementProjectSpecificIdentifier: 131

# IfcAlarm: EPS-Detektor EPS optickokouřový:EPS-Detektor EPS optickokouřový (24)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: EPS-Detektor EPS optickokouřový; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Detektor požáru
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
Name (EPS-Detektor EPS optickokouřový:EPS-Detektor EPS optickokouřový:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1492127 | 1.S | EPS Kouř.1492127 | 1 | 1.S
1494484 | 1.S | EPS Kouř.1494484 | 2 | 1.S
1494493 | 1.S | EPS Kouř.1494493 | 3 | 1.S
1494566 | 1.S mezipatro | EPS Kouř.1494566 | 4 | 1.S mezipatro
1511216 | 1.S mezipatro | EPS Kouř.1511216 | 24 | 1.S mezipatro
1521113 | 1.S | EPS Kouř.1521113 | 28 | 1.S
1521125 | 1.S | EPS Kouř.1521125 | 29 | 1.S
1521187 | 1.S | EPS Kouř.1521187 | 31 | 1.S
1527630 | 1.NP mezipatro | EPS Kouř.1527630 | 34 | 1.NP mezipatro
1527828 | 2.NP mezipatro | EPS Kouř.1527828 | 35 | 2.NP mezipatro
1528015 | 3.NP mezipatro | EPS Kouř.1528015 | 36 | 3.NP mezipatro
1528248 | 4.NP mezipatro | EPS Kouř.1528248 | 37 | 4.NP mezipatro
1528494 | 5.NP mezipatro | EPS Kouř.1528494 | 38 | 5.NP mezipatro
1528729 | 1.NP mezipatro | EPS Kouř.1528729 | 39 | 1.NP mezipatro
1528904 | 2.NP mezipatro | EPS Kouř.1528904 | 40 | 2.NP mezipatro
1529109 | 3.NP mezipatro | EPS Kouř.1529109 | 41 | 3.NP mezipatro
1943003 | 1.S | EPS Kouř.1943003 | 173 | 1.S
1949980 | 1.S | EPS Kouř.1949980 | 201 | 1.S
1950741 | 1.S | EPS Kouř.1950741 | 208 | 1.S
1953354 | 1.S | EPS Kouř.1953354 | 220 | 1.S
1979861 | 1.S | EPS Kouř.1979861 | 253 | 1.S
1989467 | 5.NP mezipatro | EPS Kouř.1989467 | 267 | 5.NP mezipatro
1989496 | 4.NP mezipatro | EPS Kouř.1989496 | 268 | 4.NP mezipatro
2003697 | 5.NP mezipatro | EPS Kouř.2003697 | 286 | 5.NP mezipatro

# IfcAlarm: EPS-Tlačítko_EPS:EPS-Tlačítko_EPS (53)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: EPS-Tlačítko_EPS; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Prolamovací požární tlačítko.
Type - CZ_DTcommon - DT_name: tlačítkový hlásič EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: QAB
Name (EPS-Tlačítko_EPS:EPS-Tlačítko_EPS:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1503213 | 1.S | EPS tlačítko.1503213 | 9 | 1.S
1507570 | 1.S | EPS tlačítko.1507570 | 15 | 1.S
1508903 | 1.S | EPS tlačítko.1508903 | 19 | 1.S
1509070 | 1.S | EPS tlačítko.1509070 | 20 | 1.S
1509077 | 1.S mezipatro | EPS tlačítko.1509077 | 21 | 1.S mezipatro
1509186 | 1.S mezipatro | EPS tlačítko.1509186 | 22 | 1.S mezipatro
1579251 | 2.NP mezipatro | EPS tlačítko.1579251 | 45 | 2.NP mezipatro
1579458 | 1.NP mezipatro | EPS tlačítko.1579458 | 46 | 1.NP mezipatro
1584106 | 2.NP | EPS tlačítko.1584106 | 47 | 2.NP
1584336 | 1.NP mezipatro | EPS tlačítko.1584336 | 48 | 1.NP mezipatro
1703238 | 3.NP | EPS tlačítko.1703238 | 101 | 3.NP
1703834 | 4.NP mezipatro | EPS tlačítko.1703834 | 102 | 4.NP mezipatro
1703860 | 5.NP | EPS tlačítko.1703860 | 103 | 5.NP
1704233 | 1.NP | EPS tlačítko.1704233 | 104 | 1.NP
1704509 | 5.NP mezipatro | EPS tlačítko.1704509 | 105 | 5.NP mezipatro
1704531 | 3.NP | EPS tlačítko.1704531 | 107 | 3.NP
1707021 | 2.NP mezipatro | EPS tlačítko.1707021 | 110 | 2.NP mezipatro
1707036 | 3.NP mezipatro | EPS tlačítko.1707036 | 111 | 3.NP mezipatro
1707051 | 4.NP mezipatro | EPS tlačítko.1707051 | 112 | 4.NP mezipatro
1707511 | 5.NP mezipatro | EPS tlačítko.1707511 | 113 | 5.NP mezipatro
1707853 | 5.NP mezipatro | EPS tlačítko.1707853 | 114 | 5.NP mezipatro
1707866 | 4.NP mezipatro | EPS tlačítko.1707866 | 115 | 4.NP mezipatro
1707888 | 2.NP mezipatro | EPS tlačítko.1707888 | 117 | 2.NP mezipatro
1717248 | 1.S | EPS tlačítko.1717248 | 129 | 1.S
1717258 | 1.S | EPS tlačítko.1717258 | 130 | 1.S
1938438 | 1.S mezipatro | EPS tlačítko.1938438 | 143 | 1.S mezipatro
1939345 | 1.S mezipatro | EPS tlačítko.1939345 | 145 | 1.S mezipatro
1939744 | 1.S | EPS tlačítko.1939744 | 146 | 1.S
1940273 | 1.NP | EPS tlačítko.1940273 | 147 | 1.NP
1940294 | 4.NP | EPS tlačítko.1940294 | 149 | 4.NP
1940347 | 5.NP | EPS tlačítko.1940347 | 153 | 5.NP
1940360 | 3.NP | EPS tlačítko.1940360 | 154 | 3.NP
1941006 | 1.NP | EPS tlačítko.1941006 | 155 | 1.NP
1941007 | 2.NP | EPS tlačítko.1941007 | 156 | 2.NP
1941008 | 4.NP | EPS tlačítko.1941008 | 157 | 4.NP
1941009 | 5.NP | EPS tlačítko.1941009 | 158 | 5.NP
1941010 | 3.NP | EPS tlačítko.1941010 | 159 | 3.NP
1941316 | 1.NP mezipatro | EPS tlačítko.1941316 | 163 | 1.NP mezipatro
1941344 | 3.NP mezipatro | EPS tlačítko.1941344 | 165 | 3.NP mezipatro
1941354 | 5.NP mezipatro | EPS tlačítko.1941354 | 166 | 5.NP mezipatro
1942001 | 1.NP mezipatro | EPS tlačítko.1942001 | 168 | 1.NP mezipatro
1942002 | 2.NP mezipatro | EPS tlačítko.1942002 | 169 | 2.NP mezipatro
1942003 | 3.NP mezipatro | EPS tlačítko.1942003 | 170 | 3.NP mezipatro
1965758 | 1.S | EPS tlačítko.1965758 | 241 | 1.S
1966643 | 1.S | EPS tlačítko.1966643 | 242 | 1.S
1967257 | 4.NP | EPS tlačítko.1967257 | 243 | 4.NP
1967705 | 5.NP | EPS tlačítko.1967705 | 244 | 5.NP
1968468 | 4.NP | EPS tlačítko.1968468 | 245 | 4.NP
1968773 | 2.NP | EPS tlačítko.1968773 | 246 | 2.NP
1968922 | 1.NP | EPS tlačítko.1968922 | 247 | 1.NP
2021063 | 3.NP mezipatro | EPS tlačítko.2021063 | 291 | 3.NP mezipatro
2021072 | 4.NP mezipatro | EPS tlačítko.2021072 | 292 | 4.NP mezipatro
2037530 | 2.NP | EPS tlačítko.2037530 | 293 | 2.NP

# IfcAlarm: EPS_propojovací krabice:EPS_propojovací krabice (11)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: EPS_propojovací krabice; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Propojovací krabice
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
Name (EPS_propojovací krabice:EPS_propojovací krabice:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1991500 | 1.S | Krabice.1991500 | 269 | 1.S
1991906 | 1.S mezipatro | Krabice.1991906 | 270 | 1.S mezipatro
1992644 | 1.NP mezipatro | Krabice.1992644 | 271 | 1.NP mezipatro
1992722 | 2.NP mezipatro | Krabice.1992722 | 272 | 2.NP mezipatro
1992747 | 3.NP mezipatro | Krabice.1992747 | 273 | 3.NP mezipatro
1992770 | 4.NP mezipatro | Krabice.1992770 | 274 | 4.NP mezipatro
1992789 | 5.NP mezipatro | Krabice.1992789 | 275 | 5.NP mezipatro
1993029 | 1.NP | Krabice.1993029 | 277 | 1.NP
1993239 | 2.NP | Krabice.1993239 | 278 | 2.NP
1993296 | 3.NP | Krabice.1993296 | 279 | 3.NP
1993334 | 4.NP | Krabice.1993334 | 280 | 4.NP

# IfcAlarm: Klíčový trezor_EPS:Klíčový trezor_EPS, Klíčový trezor_EPS:Klíčový trezor_EPS:1498692
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Klíčový trezor_EPS; ElementProjectSpecificDescription: Klíčový trezor požární ochrany.
CZ_ElementCommon - ElementProjectSpecificIdentifier: 5

# IfcAlarm: Nasávací jednotka_EPS:Nasávací jednotka, Nasávací jednotka_EPS:Nasávací jednotka:1500169
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Nasávací jednotka; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Nasávací jednotka pro systémy EPS
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: QAB
CZ_ElementCommon - Reference: Nasávací jednotka.1500169; ElementProjectSpecificIdentifier: 6; StoreyProjectSpecificIdentifier: 1.S

# IfcAlarm: Nasávací otvor EPS:Nasávací otvor (2)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Nasávací otvor; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Detektor požáru nasávací
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (Nasávací otvor EPS:Nasávací otvor:...) | Reference | ElementProjectSpecificIdentifier
1741793 | Nasávací otvor.1741793 | 134
1741886 | Nasávací otvor.1741886 | 135

# IfcAlarm: OPPO_EPS:OPPO_EPS, OPPO_EPS:OPPO_EPS:1722031
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: OPPO_EPS; ElementProjectSpecificDescription: Obslužný panel požární ochrany
CZ_ElementCommon - ElementProjectSpecificIdentifier: 132

# IfcAlarm: Reproduktor tlakový ERO_001:Reproduktor tlakový ERO_001 (14)
In: 5.NP mezipatro
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Reproduktor tlakový ERO_001; ElementProjectSpecificDescription: Reproduktor; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: reproduktory EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: P; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: PJA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 5.NP mezipatro
Name (Reproduktor tlakový ERO_001:Reproduktor tlakový ERO_001:...) | Reference | ElementProjectSpecificIdentifier
1689578 | Reproduktor tlakový.1689578 | 70
1690970 | Reproduktor tlakový.1690970 | 78
1692672 | Reproduktor tlakový.1692672 | 82
1693148 | Reproduktor tlakový.1693148 | 84
1982024 | Reproduktor tlakový.1982024 | 254
1982759 | Reproduktor tlakový.1982759 | 256
1983200 | Reproduktor tlakový.1983200 | 257
1983650 | Reproduktor tlakový.1983650 | 259
1983666 | Reproduktor tlakový.1983666 | 260
1983683 | Reproduktor tlakový.1983683 | 261
1984449 | Reproduktor tlakový.1984449 | 263
1984461 | Reproduktor tlakový.1984461 | 264
1984719 | Reproduktor tlakový.1984719 | 265
1985148 | Reproduktor tlakový.1985148 | 266

# IfcAlarm: Vývod_EPS:Volný vývod (10)
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Volný vývod; ElementProjectSpecificDescription: Volný kabelový vývod - releový kontakt
Name (Vývod_EPS:Volný vývod:...) | In | ElementProjectSpecificIdentifier
1936841 | 1.S | Rozvaděč RPO
1937954 | 1.NP mezipatro | 140
1938076 | 3.NP mezipatro | 141
2002092 | 1.S | 283
2002565 | 1.S | 284
2002871 | 4.NP mezipatro | 285
2004025 | 1.S | 287
2004787 | 4.NP mezipatro | 288
2005009 | 4.NP mezipatro | 289
2005322 | 1.S | 290

# IfcAlarm: Zdroj EPS:Zdroj EPS, Zdroj EPS:Zdroj EPS:1506394
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Zdroj EPS; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Pomocný napájecí zdroj.
Type - CZ_DTcommon - DT_name: ústředna zařízení dálkového přenosu (ZDP) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: QAB
CZ_ElementCommon - Reference: Zdroj EPS 24V.1506394; ElementProjectSpecificIdentifier: 12; StoreyProjectSpecificIdentifier: 1.S

# IfcAlarm: Zábleskový_maják_EPS:Zábleskový_maják_EPS, Zábleskový_maják_EPS:Zábleskový_maják_EPS:1505351
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Zábleskový_maják_EPS; ElementProjectSpecificDescription: Zábleskový maják ke klíčovému trezoru.
CZ_ElementCommon - ElementProjectSpecificIdentifier: 11

# IfcAlarm: reproduktory EVAC:reproduktory EVAC (149)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: reproduktory EVAC; ElementProjectSpecificDescription: Reproduktor; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: reproduktory EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: P; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: PJA
Name (reproduktory EVAC:reproduktory EVAC:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1515713 | 1.S mezipatro | Reproduktor stropní.1515713 | 49 | 1.S mezipatro
1515714 | 1.S mezipatro | Reproduktor stropní.1515714 | 50 | 1.S mezipatro
1515715 | 1.S mezipatro | Reproduktor stropní.1515715 | 51 | 1.S mezipatro
1515716 | 1.S mezipatro | Reproduktor stropní.1515716 | 52 | 1.S mezipatro
1515718 | 1.S mezipatro | Reproduktor stropní.1515718 | 54 | 1.S mezipatro
1515719 | 1.S mezipatro | Reproduktor stropní.1515719 | 55 | 1.S mezipatro
1515720 | 1.S mezipatro | Reproduktor stropní.1515720 | 56 | 1.S mezipatro
1515721 | 1.S mezipatro | Reproduktor stropní.1515721 | 57 | 1.S mezipatro
1515722 | 1.S mezipatro | Reproduktor stropní.1515722 | 58 | 1.S mezipatro
1515723 | 1.S mezipatro | Reproduktor stropní.1515723 | 59 | 1.S mezipatro
1515724 | 1.S mezipatro | Reproduktor stropní.1515724 | 60 | 1.S mezipatro
1517112 | 1.NP mezipatro | Reproduktor stropní.1517112 | 67 | 1.NP mezipatro
1517125 | 1.NP mezipatro | Reproduktor stropní.1517125 | 68 | 1.NP mezipatro
1517135 | 1.NP mezipatro | Reproduktor stropní.1517135 | 69 | 1.NP mezipatro
1517147 | 1.NP mezipatro | Reproduktor stropní.1517147 | 70 | 1.NP mezipatro
1517161 | 1.NP mezipatro | Reproduktor stropní.1517161 | 71 | 1.NP mezipatro
1517177 | 1.NP mezipatro | Reproduktor stropní.1517177 | 72 | 1.NP mezipatro
1517189 | 1.NP mezipatro | Reproduktor stropní.1517189 | 73 | 1.NP mezipatro
1517287 | 1.NP mezipatro | Reproduktor stropní.1517287 | 75 | 1.NP mezipatro
1517297 | 1.NP mezipatro | Reproduktor stropní.1517297 | 76 | 1.NP mezipatro
1517311 | 1.NP mezipatro | Reproduktor stropní.1517311 | 77 | 1.NP mezipatro
1517321 | 1.NP mezipatro | Reproduktor stropní.1517321 | 78 | 1.NP mezipatro
1517441 | 2.NP | Reproduktor stropní.1517441 | 79 | 2.NP
1518030 | 2.NP | Reproduktor stropní.1518030 | 82 | 2.NP
1518042 | 2.NP | Reproduktor stropní.1518042 | 83 | 2.NP
1518066 | 2.NP | Reproduktor stropní.1518066 | 85 | 2.NP
1518080 | 2.NP | Reproduktor stropní.1518080 | 86 | 2.NP
1518094 | 2.NP | Reproduktor stropní.1518094 | 87 | 2.NP
1518110 | 2.NP | Reproduktor stropní.1518110 | 88 | 2.NP
1518124 | 2.NP | Reproduktor stropní.1518124 | 89 | 2.NP
1518136 | 2.NP | Reproduktor stropní.1518136 | 90 | 2.NP
1518150 | 2.NP | Reproduktor stropní.1518150 | 91 | 2.NP
1518478 | 2.NP mezipatro | Reproduktor stropní.1518478 | 93 | 2.NP mezipatro
1518495 | 2.NP mezipatro | Reproduktor stropní.1518495 | 94 | 2.NP mezipatro
1518503 | 2.NP mezipatro | Reproduktor stropní.1518503 | 95 | 2.NP mezipatro
1518513 | 2.NP mezipatro | Reproduktor stropní.1518513 | 96 | 2.NP mezipatro
1518525 | 2.NP mezipatro | Reproduktor stropní.1518525 | 97 | 2.NP mezipatro
1518539 | 2.NP mezipatro | Reproduktor stropní.1518539 | 98 | 2.NP mezipatro
1518549 | 2.NP mezipatro | Reproduktor stropní.1518549 | 99 | 2.NP mezipatro
1518583 | 2.NP mezipatro | Reproduktor stropní.1518583 | 101 | 2.NP mezipatro
1518597 | 2.NP mezipatro | Reproduktor stropní.1518597 | 102 | 2.NP mezipatro
1518609 | 2.NP mezipatro | Reproduktor stropní.1518609 | 103 | 2.NP mezipatro
1518621 | 2.NP mezipatro | Reproduktor stropní.1518621 | 104 | 2.NP mezipatro
1519337 | 3.NP | Reproduktor stropní.1519337 | 106 | 3.NP
1519350 | 3.NP | Reproduktor stropní.1519350 | 107 | 3.NP
1519364 | 3.NP | Reproduktor stropní.1519364 | 108 | 3.NP
1519376 | 3.NP | Reproduktor stropní.1519376 | 109 | 3.NP
1519388 | 3.NP | Reproduktor stropní.1519388 | 110 | 3.NP
1519400 | 3.NP | Reproduktor stropní.1519400 | 111 | 3.NP
1519412 | 3.NP | Reproduktor stropní.1519412 | 112 | 3.NP
1519436 | 3.NP | Reproduktor stropní.1519436 | 114 | 3.NP
1519455 | 3.NP | Reproduktor stropní.1519455 | 115 | 3.NP
1519481 | 3.NP | Reproduktor stropní.1519481 | 117 | 3.NP
1519845 | 3.NP mezipatro | Reproduktor stropní.1519845 | 118 | 3.NP mezipatro
1519858 | 3.NP mezipatro | Reproduktor stropní.1519858 | 119 | 3.NP mezipatro
1519872 | 3.NP mezipatro | Reproduktor stropní.1519872 | 120 | 3.NP mezipatro
1519886 | 3.NP mezipatro | Reproduktor stropní.1519886 | 121 | 3.NP mezipatro
1519898 | 3.NP mezipatro | Reproduktor stropní.1519898 | 122 | 3.NP mezipatro
1519910 | 3.NP mezipatro | Reproduktor stropní.1519910 | 123 | 3.NP mezipatro
1519918 | 3.NP mezipatro | Reproduktor stropní.1519918 | 124 | 3.NP mezipatro
1519944 | 3.NP mezipatro | Reproduktor stropní.1519944 | 126 | 3.NP mezipatro
1519958 | 3.NP mezipatro | Reproduktor stropní.1519958 | 127 | 3.NP mezipatro
1519970 | 3.NP mezipatro | Reproduktor stropní.1519970 | 128 | 3.NP mezipatro
1519978 | 3.NP mezipatro | Reproduktor stropní.1519978 | 129 | 3.NP mezipatro
1520372 | 4.NP | Reproduktor stropní.1520372 | 138 | 4.NP
1520387 | 4.NP | Reproduktor stropní.1520387 | 139 | 4.NP
1520417 | 4.NP | Reproduktor stropní.1520417 | 141 | 4.NP
1520694 | 4.NP mezipatro | Reproduktor stropní.1520694 | 142 | 4.NP mezipatro
1520711 | 4.NP mezipatro | Reproduktor stropní.1520711 | 143 | 4.NP mezipatro
1520729 | 4.NP mezipatro | Reproduktor stropní.1520729 | 144 | 4.NP mezipatro
1520739 | 4.NP mezipatro | Reproduktor stropní.1520739 | 145 | 4.NP mezipatro
1520751 | 4.NP mezipatro | Reproduktor stropní.1520751 | 146 | 4.NP mezipatro
1520765 | 4.NP mezipatro | Reproduktor stropní.1520765 | 147 | 4.NP mezipatro
1520775 | 4.NP mezipatro | Reproduktor stropní.1520775 | 148 | 4.NP mezipatro
1520803 | 4.NP mezipatro | Reproduktor stropní.1520803 | 150 | 4.NP mezipatro
1520817 | 4.NP mezipatro | Reproduktor stropní.1520817 | 151 | 4.NP mezipatro
1520849 | 4.NP mezipatro | Reproduktor stropní.1520849 | 153 | 4.NP mezipatro
1523501 | 1.S | Reproduktor stropní.1523501 | 167 | 1.S
1523512 | 1.S | Reproduktor stropní.1523512 | 168 | 1.S
1523528 | 1.S | Reproduktor stropní.1523528 | 170 | 1.S
1523546 | 1.S | Reproduktor stropní.1523546 | 171 | 1.S
1523556 | 1.S | Reproduktor stropní.1523556 | 172 | 1.S
1523566 | 1.S | Reproduktor stropní.1523566 | 173 | 1.S
1523574 | 1.S | Reproduktor stropní.1523574 | 174 | 1.S
1523596 | 1.S | Reproduktor stropní.1523596 | 176 | 1.S
1523883 | 1.S | Reproduktor stropní.1523883 | 177 | 1.S
1523894 | 1.S | Reproduktor stropní.1523894 | 178 | 1.S
1523903 | 1.S | Reproduktor stropní.1523903 | 179 | 1.S
1523911 | 1.S | Reproduktor stropní.1523911 | 180 | 1.S
1524409 | 2.NP | Reproduktor stropní.1524409 | 182 | 2.NP
1524419 | 2.NP | Reproduktor stropní.1524419 | 183 | 2.NP
1524505 | 3.NP | Reproduktor stropní.1524505 | 184 | 3.NP
1524517 | 3.NP | Reproduktor stropní.1524517 | 185 | 3.NP
1524594 | 4.NP | Reproduktor stropní.1524594 | 186 | 4.NP
1524604 | 4.NP | Reproduktor stropní.1524604 | 187 | 4.NP
1524705 | 5.NP mezipatro | Reproduktor stropní.1524705 | 188 | 5.NP mezipatro
1524718 | 5.NP mezipatro | Reproduktor stropní.1524718 | 189 | 5.NP mezipatro
1524792 | 1.S | Reproduktor stropní.1524792 | 190 | 1.S
1526161 | 1.NP | Reproduktor stropní.1526161 | 191 | 1.NP
1526174 | 1.NP | Reproduktor stropní.1526174 | 192 | 1.NP
1526186 | 1.NP | Reproduktor stropní.1526186 | 193 | 1.NP
1526198 | 1.NP | Reproduktor stropní.1526198 | 194 | 1.NP
1526210 | 1.NP | Reproduktor stropní.1526210 | 195 | 1.NP
1526222 | 1.NP | Reproduktor stropní.1526222 | 196 | 1.NP
1526230 | 1.NP | Reproduktor stropní.1526230 | 197 | 1.NP
1526256 | 1.NP | Reproduktor stropní.1526256 | 199 | 1.NP
1526267 | 1.NP | Reproduktor stropní.1526267 | 200 | 1.NP
1526291 | 1.NP | Reproduktor stropní.1526291 | 202 | 1.NP
1526303 | 1.NP | Reproduktor stropní.1526303 | 203 | 1.NP
1526317 | 1.NP | Reproduktor stropní.1526317 | 204 | 1.NP
1572085 | 1.S | Reproduktor stropní.1572085 | 205 | 1.S
1572130 | 1.S | Reproduktor stropní.1572130 | 206 | 1.S
1652758 | 1.S | Reproduktor stropní.1652758 | 207 | 1.S
1653008 | 1.S | Reproduktor stropní.1653008 | 209 | 1.S
1684752 | 5.NP mezipatro | Reproduktor stropní.1684752 | 210 | 5.NP mezipatro
1684850 | 5.NP mezipatro | Reproduktor stropní.1684850 | 211 | 5.NP mezipatro
1684944 | 5.NP mezipatro | Reproduktor stropní.1684944 | 212 | 5.NP mezipatro
1684945 | 5.NP mezipatro | Reproduktor stropní.1684945 | 213 | 5.NP mezipatro
1684957 | 5.NP mezipatro | Reproduktor stropní.1684957 | 214 | 5.NP mezipatro
1684958 | 5.NP mezipatro | Reproduktor stropní.1684958 | 215 | 5.NP mezipatro
1684968 | 5.NP mezipatro | Reproduktor stropní.1684968 | 216 | 5.NP mezipatro
1684969 | 5.NP mezipatro | Reproduktor stropní.1684969 | 217 | 5.NP mezipatro
1710304 | 1.S | Reproduktor stropní.1710304 | 218 | 1.S
1898525 | 1.S mezipatro | Reproduktor stropní.1898525 | 222 | 1.S mezipatro
1899391 | 1.NP | Reproduktor stropní.1899391 | 223 | 1.NP
1900026 | 2.NP mezipatro | Reproduktor stropní.1900026 | 224 | 2.NP mezipatro
1902392 | 3.NP | Reproduktor stropní.1902392 | 225 | 3.NP
1902853 | 3.NP | Reproduktor stropní.1902853 | 227 | 3.NP
1903394 | 3.NP mezipatro | Reproduktor stropní.1903394 | 229 | 3.NP mezipatro
1904218 | 4.NP mezipatro | Reproduktor stropní.1904218 | 230 | 4.NP mezipatro
1904461 | 4.NP | Reproduktor stropní.1904461 | 231 | 4.NP
1905653 | 4.NP | Reproduktor stropní.1905653 | 235 | 4.NP
1905719 | 1.S | Reproduktor stropní.1905719 | 236 | 1.S
1905836 | 1.S | Reproduktor stropní.1905836 | 237 | 1.S
1906527 | 2.NP | Reproduktor stropní.1906527 | 238 | 2.NP
1949919 | 1.S | Reproduktor stropní.1949919 | 198 | 1.S
1951478 | 1.S | Reproduktor stropní.1951478 | 219 | 1.S
1959746 | 4.NP | Reproduktor stropní.1959746 | 226 | 4.NP
1959834 | 4.NP | Reproduktor stropní.1959834 | 228 | 4.NP
1959846 | 4.NP | Reproduktor stropní.1959846 | 232 | 4.NP
1959876 | 4.NP | Reproduktor stropní.1959876 | 233 | 4.NP
1959888 | 4.NP | Reproduktor stropní.1959888 | 234 | 4.NP
1959940 | 4.NP | Reproduktor stropní.1959940 | 239 | 4.NP
1960501 | 4.NP | Reproduktor stropní.1960501 | 240 | 4.NP
1973397 | 4.NP mezipatro | Reproduktor stropní.1973397 | 248 | 4.NP mezipatro
1973643 | 5.NP mezipatro | Reproduktor stropní.1973643 | 249 | 5.NP mezipatro
1973664 | 5.NP mezipatro | Reproduktor stropní.1973664 | 250 | 5.NP mezipatro
1973717 | 5.NP mezipatro | Reproduktor stropní.1973717 | 251 | 5.NP mezipatro
1973735 | 5.NP mezipatro | Reproduktor stropní.1973735 | 252 | 5.NP mezipatro

# IfcAlarm: Ústředna_EPS1:Ústředna EPS, Ústředna_EPS1:Ústředna EPS:1504371
In: 1.S
Type - Material: <Unnamed>
Type - CZ_DTcommon - DT_name: další prvky
Type - CZ_ElementCommon - ElementProjectSpecificName: Ústředna EPS; ElementProjectSpecificDescription: Ústředna systému EPS.
CZ_ElementCommon - ElementProjectSpecificIdentifier: 10

# IfcCableCarrierFitting: M_Horizontální ohyb kanálu:Standardní (3)
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: -; ElementProjectSpecificIdentifier: Koleno 90st; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové lávky a trasy EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - StoreyProjectSpecificIdentifier: 1.S
Name (M_Horizontální ohyb kanálu:Standardní:...) | Reference | Length
2033457 | Koleno 90st.2033457 | 621.24
2033731 | Koleno 90st.2033731 | 254.72
2033737 | Koleno 90st.2033737 | 254.72

# IfcCableCarrierFitting: M_Koleno elektroinstalační trubky, rovný konec, PVC:Standardní (37)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Detektor požáru
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
Name (M_Koleno elektroinstalační trubky, rovný konec, PVC:Standardní:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1829212 | 1.NP mezipatro | TK.1829212 | Kabel T3 | 1.NP mezipatro
1829222 | 1.NP mezipatro | TK.1829222 | Kabel T3 | 1.NP mezipatro
1830067 | 1.NP mezipatro | TK.1830067 | Kabel T3 | 1.NP mezipatro
1830105 | 1.NP mezipatro | TK.1830105 | Kabel T3 | 1.NP mezipatro
1831486 | 1.NP | TK.1831486 | Kabel T2 | 1.NP
1831494 | 1.NP | TK.1831494 | Kabel T2 | 1.NP
1832362 | 1.NP | TK.1832362 | Kabel T2 | 1.NP
1832744 | 1.S mezipatro | TK.1832744 | Kabel T2 | 1.S mezipatro
1832756 | 1.S mezipatro | TK.1832756 | Kabel T2 | 1.S mezipatro
1833493 | 1.S mezipatro | TK.1833493 | Kabel T2 | 1.S mezipatro
1833507 | 1.S mezipatro | TK.1833507 | Kabel T2 | 1.S mezipatro
1833513 | 1.S mezipatro | TK.1833513 | Kabel T2 | 1.S mezipatro
1833623 | 1.S mezipatro | TK.1833623 | Kabel T2 | 1.S mezipatro
1835534 | 2.NP | TK.1835534 | Kabel T3 | 2.NP
1835544 | 2.NP | TK.1835544 | Kabel T3 | 2.NP
1836530 | 2.NP | TK.1836530 | Kabel T3 | 2.NP
1837642 | 3.NP | TK.1837642 | Kabel T4 | 3.NP
1837649 | 3.NP | TK.1837649 | Kabel T4 | 3.NP
1837913 | 3.NP | TK.1837913 | Kabel T4 | 3.NP
1838406 | 4.NP | TK.1838406 | Kabel T5 | 4.NP
1838413 | 4.NP | TK.1838413 | Kabel T5 | 4.NP
1838778 | 4.NP | TK.1838778 | Kabel T5 | 4.NP
1839007 | 3.NP mezipatro | TK.1839007 | Kabel T5 | 3.NP mezipatro
1839016 | 3.NP mezipatro | TK.1839016 | Kabel T5 | 3.NP mezipatro
1840182 | 3.NP mezipatro | TK.1840182 | Kabel T5 | 3.NP mezipatro
1840277 | 3.NP mezipatro | TK.1840277 | Kabel T5 | 3.NP mezipatro
1841629 | 2.NP mezipatro | TK.1841629 | Kabel T4 | 2.NP mezipatro
1841636 | 2.NP mezipatro | TK.1841636 | Kabel T4 | 2.NP mezipatro
1841799 | 2.NP mezipatro | TK.1841799 | Kabel T4 | 2.NP mezipatro
1841904 | 2.NP mezipatro | TK.1841904 | Kabel T4 | 2.NP mezipatro
1843258 | 4.NP mezipatro | TK.1843258 | Kabel T6 | 4.NP mezipatro
1843265 | 4.NP mezipatro | TK.1843265 | Kabel T6 | 4.NP mezipatro
1843407 | 4.NP mezipatro | TK.1843407 | Kabel T6 | 4.NP mezipatro
1843503 | 4.NP mezipatro | TK.1843503 | Kabel T6 | 4.NP mezipatro
1844513 | 1.S | TK.1844513 | Kabel T1 | 1.S
1844520 | 1.S | TK.1844520 | Kabel T1 | 1.S
1844915 | 1.S | TK.1844915 | Kabel T1 | 1.S

# IfcCableCarrierFitting: M_Koleno elektroinstalační trubky, rovný konec, PVC:Standardní (305)
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Detektor požáru; ElementProjectSpecificIdentifier: TK
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
Name (M_Koleno elektroinstalační trubky, rovný konec, PVC:Standardní:...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1829059 | 1.NP mezipatro | TK.1829059 | Kabel T3 | 1.NP mezipatro
1829069 | 1.NP mezipatro | TK.1829069 | Kabel T3 | 1.NP mezipatro
1829076 | 1.NP mezipatro | TK.1829076 | Kabel T3 | 1.NP mezipatro
1829085 | 1.NP mezipatro | TK.1829085 | Kabel T3 | 1.NP mezipatro
1829092 | 1.NP mezipatro | TK.1829092 | Kabel T3 | 1.NP mezipatro
1829123 | 1.NP mezipatro | TK.1829123 | Kabel T3 | 1.NP mezipatro
1829132 | 1.NP mezipatro | TK.1829132 | Kabel T3 | 1.NP mezipatro
1829139 | 1.NP mezipatro | TK.1829139 | Kabel T3 | 1.NP mezipatro
1829148 | 1.NP mezipatro | TK.1829148 | Kabel T3 | 1.NP mezipatro
1829155 | 1.NP mezipatro | TK.1829155 | Kabel T3 | 1.NP mezipatro
1829164 | 1.NP mezipatro | TK.1829164 | Kabel T3 | 1.NP mezipatro
1829171 | 1.NP mezipatro | TK.1829171 | Kabel T3 | 1.NP mezipatro
1829180 | 1.NP mezipatro | TK.1829180 | Kabel T3 | 1.NP mezipatro
1829187 | 1.NP mezipatro | TK.1829187 | Kabel T3 | 1.NP mezipatro
1829196 | 1.NP mezipatro | TK.1829196 | Kabel T3 | 1.NP mezipatro
1829203 | 1.NP mezipatro | TK.1829203 | Kabel T3 | 1.NP mezipatro
1829229 | 1.NP mezipatro | TK.1829229 | Kabel T3 | 1.NP mezipatro
1829238 | 1.NP mezipatro | TK.1829238 | Kabel T3 | 1.NP mezipatro
1829245 | 1.NP mezipatro | TK.1829245 | Kabel T3 | 1.NP mezipatro
1829254 | 1.NP mezipatro | TK.1829254 | Kabel T3 | 1.NP mezipatro
1829261 | 1.NP mezipatro | TK.1829261 | Kabel T3 | 1.NP mezipatro
1829270 | 1.NP mezipatro | TK.1829270 | Kabel T3 | 1.NP mezipatro
1829277 | 1.NP mezipatro | TK.1829277 | Kabel T3 | 1.NP mezipatro
1829286 | 1.NP mezipatro | TK.1829286 | Kabel T3 | 1.NP mezipatro
1829293 | 1.NP mezipatro | TK.1829293 | Kabel T3 | 1.NP mezipatro
1830065 | 1.NP mezipatro | TK.1830065 | Kabel T3 | 1.NP mezipatro
1830103 | 1.NP mezipatro | TK.1830103 | Kabel T3 | 1.NP mezipatro
1831056 | 1.NP mezipatro | TK.1831056 | Kabel T3 | 1.NP mezipatro
1831059 | 1.NP mezipatro | TK.1831059 | Kabel T3 | 1.NP mezipatro
1831370 | 1.NP | TK.1831370 | Kabel T2 | 1.NP
1831381 | 1.NP | TK.1831381 | Kabel T2 | 1.NP
1831388 | 1.NP | TK.1831388 | Kabel T2 | 1.NP
1831397 | 1.NP | TK.1831397 | Kabel T2 | 1.NP
1831404 | 1.NP | TK.1831404 | Kabel T2 | 1.NP
1831413 | 1.NP | TK.1831413 | Kabel T2 | 1.NP
1831420 | 1.NP | TK.1831420 | Kabel T2 | 1.NP
1831429 | 1.NP | TK.1831429 | Kabel T2 | 1.NP
1831436 | 1.NP | TK.1831436 | Kabel T2 | 1.NP
1831445 | 1.NP | TK.1831445 | Kabel T2 | 1.NP
1831452 | 1.NP | TK.1831452 | Kabel T2 | 1.NP
1831461 | 1.NP | TK.1831461 | Kabel T2 | 1.NP
1831468 | 1.NP | TK.1831468 | Kabel T2 | 1.NP
1831477 | 1.NP | TK.1831477 | Kabel T2 | 1.NP
1831504 | 1.NP | TK.1831504 | Kabel T2 | 1.NP
1831511 | 1.NP | TK.1831511 | Kabel T2 | 1.NP
1831520 | 1.NP | TK.1831520 | Kabel T2 | 1.NP
1831527 | 1.NP | TK.1831527 | Kabel T2 | 1.NP
1831536 | 1.NP | TK.1831536 | Kabel T2 | 1.NP
1831543 | 1.NP | TK.1831543 | Kabel T2 | 1.NP
1831552 | 1.NP | TK.1831552 | Kabel T2 | 1.NP
1831559 | 1.NP | TK.1831559 | Kabel T2 | 1.NP
1831568 | 1.NP | TK.1831568 | Kabel T2 | 1.NP
1831575 | 1.NP | TK.1831575 | Kabel T2 | 1.NP
1831584 | 1.NP | TK.1831584 | Kabel T2 | 1.NP
1831591 | 1.NP | TK.1831591 | Kabel T2 | 1.NP
1832357 | 1.NP | TK.1832357 | Kabel T2 | 1.NP
1832546 | 1.S mezipatro | TK.1832546 | Kabel T2 | 1.S mezipatro
1832555 | 1.S mezipatro | TK.1832555 | Kabel T2 | 1.S mezipatro
1832562 | 1.S mezipatro | TK.1832562 | Kabel T2 | 1.S mezipatro
1832571 | 1.S mezipatro | TK.1832571 | Kabel T2 | 1.S mezipatro
1832578 | 1.S mezipatro | TK.1832578 | Kabel T2 | 1.S mezipatro
1832680 | 1.S mezipatro | TK.1832680 | Kabel T2 | 1.S mezipatro
1832687 | 1.S mezipatro | TK.1832687 | Kabel T2 | 1.S mezipatro
1832696 | 1.S mezipatro | TK.1832696 | Kabel T2 | 1.S mezipatro
1832703 | 1.S mezipatro | TK.1832703 | Kabel T2 | 1.S mezipatro
1832712 | 1.S mezipatro | TK.1832712 | Kabel T2 | 1.S mezipatro
1832719 | 1.S mezipatro | TK.1832719 | Kabel T2 | 1.S mezipatro
1832728 | 1.S mezipatro | TK.1832728 | Kabel T2 | 1.S mezipatro
1832735 | 1.S mezipatro | TK.1832735 | Kabel T2 | 1.S mezipatro
1832764 | 1.S mezipatro | TK.1832764 | Kabel T2 | 1.S mezipatro
1832773 | 1.S mezipatro | TK.1832773 | Kabel T2 | 1.S mezipatro
1832780 | 1.S mezipatro | TK.1832780 | Kabel T2 | 1.S mezipatro
1832789 | 1.S mezipatro | TK.1832789 | Kabel T2 | 1.S mezipatro
1832796 | 1.S mezipatro | TK.1832796 | Kabel T2 | 1.S mezipatro
1832805 | 1.S mezipatro | TK.1832805 | Kabel T2 | 1.S mezipatro
1832812 | 1.S mezipatro | TK.1832812 | Kabel T2 | 1.S mezipatro
1832821 | 1.S mezipatro | TK.1832821 | Kabel T2 | 1.S mezipatro
1832828 | 1.S mezipatro | TK.1832828 | Kabel T2 | 1.S mezipatro
1833621 | 1.S mezipatro | TK.1833621 | Kabel T2 | 1.S mezipatro
1835420 | 2.NP | TK.1835420 | Kabel T3 | 2.NP
1835429 | 2.NP | TK.1835429 | Kabel T3 | 2.NP
1835436 | 2.NP | TK.1835436 | Kabel T3 | 2.NP
1835445 | 2.NP | TK.1835445 | Kabel T3 | 2.NP
1835452 | 2.NP | TK.1835452 | Kabel T3 | 2.NP
1835461 | 2.NP | TK.1835461 | Kabel T3 | 2.NP
1835468 | 2.NP | TK.1835468 | Kabel T3 | 2.NP
1835477 | 2.NP | TK.1835477 | Kabel T3 | 2.NP
1835484 | 2.NP | TK.1835484 | Kabel T3 | 2.NP
1835493 | 2.NP | TK.1835493 | Kabel T3 | 2.NP
1835500 | 2.NP | TK.1835500 | Kabel T3 | 2.NP
1835509 | 2.NP | TK.1835509 | Kabel T3 | 2.NP
1835516 | 2.NP | TK.1835516 | Kabel T3 | 2.NP
1835525 | 2.NP | TK.1835525 | Kabel T3 | 2.NP
1835553 | 2.NP | TK.1835553 | Kabel T3 | 2.NP
1835560 | 2.NP | TK.1835560 | Kabel T3 | 2.NP
1835569 | 2.NP | TK.1835569 | Kabel T3 | 2.NP
1835576 | 2.NP | TK.1835576 | Kabel T3 | 2.NP
1835585 | 2.NP | TK.1835585 | Kabel T3 | 2.NP
1835592 | 2.NP | TK.1835592 | Kabel T3 | 2.NP
1835601 | 2.NP | TK.1835601 | Kabel T3 | 2.NP
1835608 | 2.NP | TK.1835608 | Kabel T3 | 2.NP
1835617 | 2.NP | TK.1835617 | Kabel T3 | 2.NP
1835624 | 2.NP | TK.1835624 | Kabel T3 | 2.NP
1835633 | 2.NP | TK.1835633 | Kabel T3 | 2.NP
1835659 | 2.NP | TK.1835659 | Kabel T3 | 2.NP
1836533 | 2.NP | TK.1836533 | Kabel T3 | 2.NP
1837530 | 3.NP | TK.1837530 | Kabel T4 | 3.NP
1837539 | 3.NP | TK.1837539 | Kabel T4 | 3.NP
1837546 | 3.NP | TK.1837546 | Kabel T4 | 3.NP
1837555 | 3.NP | TK.1837555 | Kabel T4 | 3.NP
1837562 | 3.NP | TK.1837562 | Kabel T4 | 3.NP
1837571 | 3.NP | TK.1837571 | Kabel T4 | 3.NP
1837578 | 3.NP | TK.1837578 | Kabel T4 | 3.NP
1837587 | 3.NP | TK.1837587 | Kabel T4 | 3.NP
1837594 | 3.NP | TK.1837594 | Kabel T4 | 3.NP
1837603 | 3.NP | TK.1837603 | Kabel T4 | 3.NP
1837610 | 3.NP | TK.1837610 | Kabel T4 | 3.NP
1837619 | 3.NP | TK.1837619 | Kabel T4 | 3.NP
1837626 | 3.NP | TK.1837626 | Kabel T4 | 3.NP
1837635 | 3.NP | TK.1837635 | Kabel T4 | 3.NP
1837658 | 3.NP | TK.1837658 | Kabel T4 | 3.NP
1837665 | 3.NP | TK.1837665 | Kabel T4 | 3.NP
1837674 | 3.NP | TK.1837674 | Kabel T4 | 3.NP
1837681 | 3.NP | TK.1837681 | Kabel T4 | 3.NP
1837690 | 3.NP | TK.1837690 | Kabel T4 | 3.NP
1837697 | 3.NP | TK.1837697 | Kabel T4 | 3.NP
1837706 | 3.NP | TK.1837706 | Kabel T4 | 3.NP
1837713 | 3.NP | TK.1837713 | Kabel T4 | 3.NP
1837722 | 3.NP | TK.1837722 | Kabel T4 | 3.NP
1837729 | 3.NP | TK.1837729 | Kabel T4 | 3.NP
1837738 | 3.NP | TK.1837738 | Kabel T4 | 3.NP
1837755 | 3.NP | TK.1837755 | Kabel T4 | 3.NP
1837916 | 3.NP | TK.1837916 | Kabel T4 | 3.NP
1838294 | 4.NP | TK.1838294 | Kabel T5 | 4.NP
1838303 | 4.NP | TK.1838303 | Kabel T5 | 4.NP
1838310 | 4.NP | TK.1838310 | Kabel T5 | 4.NP
1838319 | 4.NP | TK.1838319 | Kabel T5 | 4.NP
1838326 | 4.NP | TK.1838326 | Kabel T5 | 4.NP
1838335 | 4.NP | TK.1838335 | Kabel T5 | 4.NP
1838342 | 4.NP | TK.1838342 | Kabel T5 | 4.NP
1838351 | 4.NP | TK.1838351 | Kabel T5 | 4.NP
1838358 | 4.NP | TK.1838358 | Kabel T5 | 4.NP
1838367 | 4.NP | TK.1838367 | Kabel T5 | 4.NP
1838374 | 4.NP | TK.1838374 | Kabel T5 | 4.NP
1838383 | 4.NP | TK.1838383 | Kabel T5 | 4.NP
1838390 | 4.NP | TK.1838390 | Kabel T5 | 4.NP
1838399 | 4.NP | TK.1838399 | Kabel T5 | 4.NP
1838422 | 4.NP | TK.1838422 | Kabel T5 | 4.NP
1838429 | 4.NP | TK.1838429 | Kabel T5 | 4.NP
1838438 | 4.NP | TK.1838438 | Kabel T5 | 4.NP
1838445 | 4.NP | TK.1838445 | Kabel T5 | 4.NP
1838454 | 4.NP | TK.1838454 | Kabel T5 | 4.NP
1838461 | 4.NP | TK.1838461 | Kabel T5 | 4.NP
1838470 | 4.NP | TK.1838470 | Kabel T5 | 4.NP
1838477 | 4.NP | TK.1838477 | Kabel T5 | 4.NP
1838486 | 4.NP | TK.1838486 | Kabel T5 | 4.NP
1838493 | 4.NP | TK.1838493 | Kabel T5 | 4.NP
1838502 | 4.NP | TK.1838502 | Kabel T5 | 4.NP
1838514 | 4.NP | TK.1838514 | Kabel T5 | 4.NP
1838776 | 4.NP | TK.1838776 | Kabel T5 | 4.NP
1838849 | 3.NP mezipatro | TK.1838849 | Kabel T5 | 3.NP mezipatro
1838858 | 3.NP mezipatro | TK.1838858 | Kabel T5 | 3.NP mezipatro
1838865 | 3.NP mezipatro | TK.1838865 | Kabel T5 | 3.NP mezipatro
1838874 | 3.NP mezipatro | TK.1838874 | Kabel T5 | 3.NP mezipatro
1838881 | 3.NP mezipatro | TK.1838881 | Kabel T5 | 3.NP mezipatro
1838890 | 3.NP mezipatro | TK.1838890 | Kabel T5 | 3.NP mezipatro
1838916 | 3.NP mezipatro | TK.1838916 | Kabel T5 | 3.NP mezipatro
1838925 | 3.NP mezipatro | TK.1838925 | Kabel T5 | 3.NP mezipatro
1838932 | 3.NP mezipatro | TK.1838932 | Kabel T5 | 3.NP mezipatro
1838941 | 3.NP mezipatro | TK.1838941 | Kabel T5 | 3.NP mezipatro
1838948 | 3.NP mezipatro | TK.1838948 | Kabel T5 | 3.NP mezipatro
1838957 | 3.NP mezipatro | TK.1838957 | Kabel T5 | 3.NP mezipatro
1838964 | 3.NP mezipatro | TK.1838964 | Kabel T5 | 3.NP mezipatro
1838973 | 3.NP mezipatro | TK.1838973 | Kabel T5 | 3.NP mezipatro
1838980 | 3.NP mezipatro | TK.1838980 | Kabel T5 | 3.NP mezipatro
1838989 | 3.NP mezipatro | TK.1838989 | Kabel T5 | 3.NP mezipatro
1838998 | 3.NP mezipatro | TK.1838998 | Kabel T5 | 3.NP mezipatro
1839023 | 3.NP mezipatro | TK.1839023 | Kabel T5 | 3.NP mezipatro
1839032 | 3.NP mezipatro | TK.1839032 | Kabel T5 | 3.NP mezipatro
1839039 | 3.NP mezipatro | TK.1839039 | Kabel T5 | 3.NP mezipatro
1839048 | 3.NP mezipatro | TK.1839048 | Kabel T5 | 3.NP mezipatro
1839055 | 3.NP mezipatro | TK.1839055 | Kabel T5 | 3.NP mezipatro
1839064 | 3.NP mezipatro | TK.1839064 | Kabel T5 | 3.NP mezipatro
1839071 | 3.NP mezipatro | TK.1839071 | Kabel T5 | 3.NP mezipatro
1839080 | 3.NP mezipatro | TK.1839080 | Kabel T5 | 3.NP mezipatro
1839087 | 3.NP mezipatro | TK.1839087 | Kabel T5 | 3.NP mezipatro
1840275 | 3.NP mezipatro | TK.1840275 | Kabel T5 | 3.NP mezipatro
1840504 | 3.NP mezipatro | TK.1840504 | Kabel T5 | 3.NP mezipatro
1840507 | 3.NP mezipatro | TK.1840507 | Kabel T5 | 3.NP mezipatro
1841478 | 2.NP mezipatro | TK.1841478 | Kabel T4 | 2.NP mezipatro
1841487 | 2.NP mezipatro | TK.1841487 | Kabel T4 | 2.NP mezipatro
1841494 | 2.NP mezipatro | TK.1841494 | Kabel T4 | 2.NP mezipatro
1841503 | 2.NP mezipatro | TK.1841503 | Kabel T4 | 2.NP mezipatro
1841510 | 2.NP mezipatro | TK.1841510 | Kabel T4 | 2.NP mezipatro
1841540 | 2.NP mezipatro | TK.1841540 | Kabel T4 | 2.NP mezipatro
1841549 | 2.NP mezipatro | TK.1841549 | Kabel T4 | 2.NP mezipatro
1841556 | 2.NP mezipatro | TK.1841556 | Kabel T4 | 2.NP mezipatro
1841565 | 2.NP mezipatro | TK.1841565 | Kabel T4 | 2.NP mezipatro
1841572 | 2.NP mezipatro | TK.1841572 | Kabel T4 | 2.NP mezipatro
1841581 | 2.NP mezipatro | TK.1841581 | Kabel T4 | 2.NP mezipatro
1841588 | 2.NP mezipatro | TK.1841588 | Kabel T4 | 2.NP mezipatro
1841597 | 2.NP mezipatro | TK.1841597 | Kabel T4 | 2.NP mezipatro
1841604 | 2.NP mezipatro | TK.1841604 | Kabel T4 | 2.NP mezipatro
1841613 | 2.NP mezipatro | TK.1841613 | Kabel T4 | 2.NP mezipatro
1841620 | 2.NP mezipatro | TK.1841620 | Kabel T4 | 2.NP mezipatro
1841643 | 2.NP mezipatro | TK.1841643 | Kabel T4 | 2.NP mezipatro
1841652 | 2.NP mezipatro | TK.1841652 | Kabel T4 | 2.NP mezipatro
1841659 | 2.NP mezipatro | TK.1841659 | Kabel T4 | 2.NP mezipatro
1841668 | 2.NP mezipatro | TK.1841668 | Kabel T4 | 2.NP mezipatro
1841675 | 2.NP mezipatro | TK.1841675 | Kabel T4 | 2.NP mezipatro
1841684 | 2.NP mezipatro | TK.1841684 | Kabel T4 | 2.NP mezipatro
1841691 | 2.NP mezipatro | TK.1841691 | Kabel T4 | 2.NP mezipatro
1841700 | 2.NP mezipatro | TK.1841700 | Kabel T4 | 2.NP mezipatro
1841707 | 2.NP mezipatro | TK.1841707 | Kabel T4 | 2.NP mezipatro
1841803 | 2.NP mezipatro | TK.1841803 | Kabel T4 | 2.NP mezipatro
1841902 | 2.NP mezipatro | TK.1841902 | Kabel T4 | 2.NP mezipatro
1841948 | 2.NP mezipatro | TK.1841948 | Kabel T4 | 2.NP mezipatro
1841951 | 2.NP mezipatro | TK.1841951 | Kabel T4 | 2.NP mezipatro
1842608 | 4.NP mezipatro | TK.1842608 | Kabel T6 | 4.NP mezipatro
1842617 | 4.NP mezipatro | TK.1842617 | Kabel T6 | 4.NP mezipatro
1842624 | 4.NP mezipatro | TK.1842624 | Kabel T6 | 4.NP mezipatro
1842633 | 4.NP mezipatro | TK.1842633 | Kabel T6 | 4.NP mezipatro
1842640 | 4.NP mezipatro | TK.1842640 | Kabel T6 | 4.NP mezipatro
1843161 | 4.NP mezipatro | TK.1843161 | Kabel T6 | 4.NP mezipatro
1843170 | 4.NP mezipatro | TK.1843170 | Kabel T6 | 4.NP mezipatro
1843177 | 4.NP mezipatro | TK.1843177 | Kabel T6 | 4.NP mezipatro
1843186 | 4.NP mezipatro | TK.1843186 | Kabel T6 | 4.NP mezipatro
1843193 | 4.NP mezipatro | TK.1843193 | Kabel T6 | 4.NP mezipatro
1843205 | 4.NP mezipatro | TK.1843205 | Kabel T6 | 4.NP mezipatro
1843212 | 4.NP mezipatro | TK.1843212 | Kabel T6 | 4.NP mezipatro
1843223 | 4.NP mezipatro | TK.1843223 | Kabel T6 | 4.NP mezipatro
1843230 | 4.NP mezipatro | TK.1843230 | Kabel T6 | 4.NP mezipatro
1843239 | 4.NP mezipatro | TK.1843239 | Kabel T6 | 4.NP mezipatro
1843246 | 4.NP mezipatro | TK.1843246 | Kabel T6 | 4.NP mezipatro
1843272 | 4.NP mezipatro | TK.1843272 | Kabel T6 | 4.NP mezipatro
1843281 | 4.NP mezipatro | TK.1843281 | Kabel T6 | 4.NP mezipatro
1843288 | 4.NP mezipatro | TK.1843288 | Kabel T6 | 4.NP mezipatro
1843297 | 4.NP mezipatro | TK.1843297 | Kabel T6 | 4.NP mezipatro
1843304 | 4.NP mezipatro | TK.1843304 | Kabel T6 | 4.NP mezipatro
1843313 | 4.NP mezipatro | TK.1843313 | Kabel T6 | 4.NP mezipatro
1843320 | 4.NP mezipatro | TK.1843320 | Kabel T6 | 4.NP mezipatro
1843329 | 4.NP mezipatro | TK.1843329 | Kabel T6 | 4.NP mezipatro
1843336 | 4.NP mezipatro | TK.1843336 | Kabel T6 | 4.NP mezipatro
1843410 | 4.NP mezipatro | TK.1843410 | Kabel T6 | 4.NP mezipatro
1843501 | 4.NP mezipatro | TK.1843501 | Kabel T6 | 4.NP mezipatro
1843543 | 4.NP mezipatro | TK.1843543 | Kabel T6 | 4.NP mezipatro
1843546 | 4.NP mezipatro | TK.1843546 | Kabel T6 | 4.NP mezipatro
1843901 | 5.NP | TK.1843901 | Kabel T6 | 5.NP
1843910 | 5.NP | TK.1843910 | Kabel T6 | 5.NP
1843917 | 5.NP | TK.1843917 | Kabel T6 | 5.NP
1843926 | 5.NP | TK.1843926 | Kabel T6 | 5.NP
1843935 | 5.NP | TK.1843935 | Kabel T6 | 5.NP
1843944 | 5.NP | TK.1843944 | Kabel T6 | 5.NP
1843953 | 5.NP | TK.1843953 | Kabel T6 | 5.NP
1843962 | 5.NP | TK.1843962 | Kabel T6 | 5.NP
1843971 | 5.NP | TK.1843971 | Kabel T6 | 5.NP
1843980 | 5.NP | TK.1843980 | Kabel T6 | 5.NP
1843989 | 5.NP | TK.1843989 | Kabel T6 | 5.NP
1843998 | 5.NP | TK.1843998 | Kabel T6 | 5.NP
1844007 | 5.NP | TK.1844007 | Kabel T6 | 5.NP
1844016 | 5.NP | TK.1844016 | Kabel T6 | 5.NP
1844025 | 5.NP | TK.1844025 | Kabel T6 | 5.NP
1844034 | 5.NP | TK.1844034 | Kabel T6 | 5.NP
1844043 | 5.NP | TK.1844043 | Kabel T6 | 5.NP
1844052 | 5.NP | TK.1844052 | Kabel T6 | 5.NP
1844061 | 5.NP | TK.1844061 | Kabel T6 | 5.NP
1844070 | 5.NP | TK.1844070 | Kabel T6 | 5.NP
1844077 | 5.NP | TK.1844077 | Kabel T6 | 5.NP
1844086 | 5.NP | TK.1844086 | Kabel T6 | 5.NP
1844408 | 1.S | TK.1844408 | Kabel T1 | 1.S
1844415 | 1.S | TK.1844415 | Kabel T1 | 1.S
1844442 | 1.S | TK.1844442 | Kabel T1 | 1.S
1844449 | 1.S | TK.1844449 | Kabel T1 | 1.S
1844458 | 1.S | TK.1844458 | Kabel T1 | 1.S
1844465 | 1.S | TK.1844465 | Kabel T1 | 1.S
1844474 | 1.S | TK.1844474 | Kabel T1 | 1.S
1844481 | 1.S | TK.1844481 | Kabel T1 | 1.S
1844490 | 1.S | TK.1844490 | Kabel T1 | 1.S
1844497 | 1.S | TK.1844497 | Kabel T1 | 1.S
1844506 | 1.S | TK.1844506 | Kabel T1 | 1.S
1844529 | 1.S | TK.1844529 | Kabel T1 | 1.S
1844536 | 1.S | TK.1844536 | Kabel T1 | 1.S
1844545 | 1.S | TK.1844545 | Kabel T1 | 1.S
1844552 | 1.S | TK.1844552 | Kabel T1 | 1.S
1844561 | 1.S | TK.1844561 | Kabel T1 | 1.S
1844568 | 1.S | TK.1844568 | Kabel T1 | 1.S
1844577 | 1.S | TK.1844577 | Kabel T1 | 1.S
1844584 | 1.S | TK.1844584 | Kabel T1 | 1.S
1844593 | 1.S | TK.1844593 | Kabel T1 | 1.S
1844600 | 1.S | TK.1844600 | Kabel T1 | 1.S
1844609 | 1.S | TK.1844609 | Kabel T1 | 1.S
1844618 | 1.S | TK.1844618 | Kabel T1 | 1.S
1844842 | 1.S | TK.1844842 | Kabel T1 | 1.S
1929100 | 1.S | TK.1929100 | Kabel T1 | 1.S
2037999 | 1.S mezipatro | TK.2037999 |  | 1.S mezipatro
2042048 | 1.S mezipatro | TK.2042048 |  | 1.S mezipatro
2042050 | 1.S mezipatro | TK.2042050 |  | 1.S mezipatro
2043193 | 1.S mezipatro | TK.2043193 |  | 1.S mezipatro
2043196 | 1.S mezipatro | TK.2043196 |  | 1.S mezipatro
2043208 | 1.S mezipatro | TK.2043208 |  | 1.S mezipatro
2043211 | 1.S mezipatro | TK.2043211 |  | 1.S mezipatro
2043214 | 1.S | TK.2043214 |  | 1.S
2043219 | 1.S | TK.2043219 |  | 1.S
2044626 | 1.S | TK.2044626 |  | 1.S
2044680 | 1.S | TK.2044680 |  | 1.S

# IfcCableCarrierFitting: M_Redukce kanálu:Standardní, M_Redukce kanálu:Standardní:2033458
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové lávky a trasy EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - Reference: .2033458; ElementProjectSpecificDescription: -; ElementProjectSpecificIdentifier: Žlab; StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 300

# IfcCableCarrierFitting: M_Vertikální vnitřní ohyb kanálu:Standardní, M_Vertikální vnitřní ohyb kanálu:Standardní:2033775
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: -; ElementProjectSpecificIdentifier: Koleno; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové lávky a trasy EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - Reference: Koleno.2033775; StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 71.33

# IfcCableCarrierFitting: M_Vertikální vnější ohyb kanálu:Standardní, M_Vertikální vnější ohyb kanálu:Standardní:2033778
In: 1.S
Type - Material: <Unnamed>
Type - CZ_ElementCommon - ElementProjectSpecificName: Standardní; ElementProjectSpecificDescription: -; ElementProjectSpecificIdentifier: Koleno; ElementProjectObjectIdentifier: SO01
Type - CZ_DTcommon - DT_name: kabelové lávky a trasy EVAC
Type - CZ_CCI - CCI_FunctionalSystemsCode: K; CCI_TechnicalSystemsCode: BH; CCI_ComponentsCode: UBA
CZ_ElementCommon - Reference: Koleno.2033778; StoreyProjectSpecificIdentifier: 1.S
Qto_CableSegmentBaseQuantities - Length: 221.33

# IfcCableCarrierSegment: Elektroinstalační trubka s tvarovkami:Pevná elektroinstalační trubka (RNC, výkaz 40) (9)
Type - PredefinedType: CONDUITSEGMENT
Type - CZ_ElementCommon - ElementProjectSpecificName: Pevná elektroinstalační trubka (RNC, výkaz 40); ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Detektor požáru; ElementProjectSpecificIdentifier: TK
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
Name (Elektroinstalační trubka s tvarovkami:Pevná elektroinstalační trubka (RNC, výkaz 40):...) | In | Reference | StoreyProjectSpecificIdentifier
2043177 | 1.S | TK.2043177 | 1.S
2043189 | 1.S mezipatro | TK.2043189 | 1.S mezipatro
2043190 | 1.S | TK.2043190 | 1.S
2043204 | 1.S mezipatro | TK.2043204 | 1.S mezipatro
2043205 | 1.S | TK.2043205 | 1.S
2044572 | 1.S | TK.2044572 | 1.S
2044632 | 1.S | TK.2044632 | 1.S
2044648 | 1.S | TK.2044648 | 1.S
2044686 | 1.S | TK.2044686 | 1.S

# IfcCableCarrierSegment: Elektroinstalační trubka s tvarovkami:Pevná elektroinstalační trubka (RNC, výkaz 40) (366)
Type - CZ_ElementCommon - ElementProjectSpecificName: Pevná elektroinstalační trubka (RNC, výkaz 40); ElementProjectObjectIdentifier: SO01; ElementProjectSpecificDescription: Detektor požáru
Type - CZ_DTcommon - DT_name: automatický hlásič (čidlo, senzor) EPS
Type - CZ_CCI - CCI_FunctionalSystemsCode: L; CCI_TechnicalSystemsCode: LB; CCI_ComponentsCode: BUA
Name (Elektroinstalační trubka s tvarovkami:Pevná elektroinstalační trubka (RNC, výkaz 40):...) | In | Reference | ElementProjectSpecificIdentifier | StoreyProjectSpecificIdentifier
1829047 | 1.NP mezipatro | TK.1829047 | Kabel T3 | 1.NP mezipatro
1829054 | 1.NP mezipatro | TK.1829054 | Kabel T3 | 1.NP mezipatro
1829062 | 1.NP mezipatro | TK.1829062 | Kabel T3 | 1.NP mezipatro
1829071 | 1.NP mezipatro | TK.1829071 | Kabel T3 | 1.NP mezipatro
1829078 | 1.NP mezipatro | TK.1829078 | Kabel T3 | 1.NP mezipatro
1829087 | 1.NP mezipatro | TK.1829087 | Kabel T3 | 1.NP mezipatro
1829103 | 1.NP mezipatro | TK.1829103 | Kabel T3 | 1.NP mezipatro
1829111 | 1.NP mezipatro | TK.1829111 | Kabel T3 | 1.NP mezipatro
1829118 | 1.NP mezipatro | TK.1829118 | Kabel T3 | 1.NP mezipatro
1829125 | 1.NP mezipatro | TK.1829125 | Kabel T3 | 1.NP mezipatro
1829134 | 1.NP mezipatro | TK.1829134 | Kabel T3 | 1.NP mezipatro
1829141 | 1.NP mezipatro | TK.1829141 | Kabel T3 | 1.NP mezipatro
1829150 | 1.NP mezipatro | TK.1829150 | Kabel T3 | 1.NP mezipatro
1829157 | 1.NP mezipatro | TK.1829157 | Kabel T3 | 1.NP mezipatro
1829166 | 1.NP mezipatro | TK.1829166 | Kabel T3 | 1.NP mezipatro
1829173 | 1.NP mezipatro | TK.1829173 | Kabel T3 | 1.NP mezipatro
1829182 | 1.NP mezipatro | TK.1829182 | Kabel T3 | 1.NP mezipatro
1829189 | 1.NP mezipatro | TK.1829189 | Kabel T3 | 1.NP mezipatro
1829198 | 1.NP mezipatro | TK.1829198 | Kabel T3 | 1.NP mezipatro
1829205 | 1.NP mezipatro | TK.1829205 | Kabel T3 | 1.NP mezipatro
1829215 | 1.NP mezipatro | TK.1829215 | Kabel T3 | 1.NP mezipatro
1829224 | 1.NP mezipatro | TK.1829224 | Kabel T3 | 1.NP mezipatro
1829231 | 1.NP mezipatro | TK.1829231 | Kabel T3 | 1.NP mezipatro
1829240 | 1.NP mezipatro | TK.1829240 | Kabel T3 | 1.NP mezipatro
1829247 | 1.NP mezipatro | TK.1829247 | Kabel T3 | 1.NP mezipatro
1829256 | 1.NP mezipatro | TK.1829256 | Kabel T3 | 1.NP mezipatro
1829263 | 1.NP mezipatro | TK.1829263 | Kabel T3 | 1.NP mezipatro
1829272 | 1.NP mezipatro | TK.1829272 | Kabel T3 | 1.NP mezipatro
1829279 | 1.NP mezipatro | TK.1829279 | Kabel T3 | 1.NP mezipatro
1829288 | 1.NP mezipatro | TK.1829288 | Kabel T3 | 1.NP mezipatro
1829304 | 1.NP mezipatro | TK.1829304 | Kabel T3 | 1.NP mezipatro
1829312 | 1.NP mezipatro | TK.1829312 | Kabel T3 | 1.NP mezipatro
1829969 | 1.NP mezipatro | TK.1829969 | Kabel T3 | 1.NP mezipatro
1830080 | 1.NP mezipatro | TK.1830080 | Kabel T3 | 1.NP mezipatro
1830118 | 1.NP mezipatro | TK.1830118 | Kabel T3 | 1.NP mezipatro
1830448 | 2.NP | TK.1830448 | Kabel T3 | 2.NP
1830469 | 2.NP | TK.1830469 | Kabel T3 | 2.NP
1831047 | 1.NP mezipatro | TK.1831047 | Kabel T3 | 1.NP mezipatro
1831358 | 1.NP | TK.1831358 | Kabel T2 | 1.NP
1831365 | 1.NP | TK.1831365 | Kabel T2 | 1.NP
1831372 | 1.NP | TK.1831372 | Kabel T2 | 1.NP
1831383 | 1.NP | TK.1831383 | Kabel T2 | 1.NP
1831390 | 1.NP | TK.1831390 | Kabel T2 | 1.NP
1831399 | 1.NP | TK.1831399 | Kabel T2 | 1.NP
1831406 | 1.NP | TK.1831406 | Kabel T2 | 1.NP
1831415 | 1.NP | TK.1831415 | Kabel T2 | 1.NP
1831422 | 1.NP | TK.1831422 | Kabel T2 | 1.NP
1831431 | 1.NP | TK.1831431 | Kabel T2 | 1.NP
1831438 | 1.NP | TK.1831438 | Kabel T2 | 1.NP
1831447 | 1.NP | TK.1831447 | Kabel T2 | 1.NP
1831454 | 1.NP | TK.1831454 | Kabel T2 | 1.NP
1831463 | 1.NP | TK.1831463 | Kabel T2 | 1.NP
1831470 | 1.NP | TK.1831470 | Kabel T2 | 1.NP
1831479 | 1.NP | TK.1831479 | Kabel T2 | 1.NP
1831489 | 1.NP | TK.1831489 | Kabel T2 | 1.NP
1831497 | 1.NP | TK.1831497 | Kabel T2 | 1.NP
1831506 | 1.NP | TK.1831506 | Kabel T2 | 1.NP
1831513 | 1.NP | TK.1831513 | Kabel T2 | 1.NP
1831522 | 1.NP | TK.1831522 | Kabel T2 | 1.NP
1831529 | 1.NP | TK.1831529 | Kabel T2 | 1.NP
1831538 | 1.NP | TK.1831538 | Kabel T2 | 1.NP
1831545 | 1.NP | TK.1831545 | Kabel T2 | 1.NP
1831554 | 1.NP | TK.1831554 | Kabel T2 | 1.NP
1831561 | 1.NP | TK.1831561 | Kabel T2 | 1.NP
1831570 | 1.NP | TK.1831570 | Kabel T2 | 1.NP
1831577 | 1.NP | TK.1831577 | Kabel T2 | 1.NP
1831586 | 1.NP | TK.1831586 | Kabel T2 | 1.NP
1831921 | 1.NP | TK.1831921 | Kabel T2 | 1.NP
1832346 | 1.NP | TK.1832346 | Kabel T2 | 1.NP
1832534 | 1.S mezipatro | TK.1832534 | Kabel T2 | 1.S mezipatro
1832541 | 1.S mezipatro | TK.1832541 | Kabel T2 | 1.S mezipatro
1832548 | 1.S mezipatro | TK.1832548 | Kabel T2 | 1.S mezipatro
1832557 | 1.S mezipatro | TK.1832557 | Kabel T2 | 1.S mezipatro
1832564 | 1.S mezipatro | TK.1832564 | Kabel T2 | 1.S mezipatro
1832573 | 1.S mezipatro | TK.1832573 | Kabel T2 | 1.S mezipatro
1832643 | 1.S mezipatro | TK.1832643 | Kabel T2 | 1.S mezipatro
1832650 | 1.S mezipatro | TK.1832650 | Kabel T2 | 1.S mezipatro
1832657 | 1.S mezipatro | TK.1832657 | Kabel T2 | 1.S mezipatro
1832666 | 1.S mezipatro | TK.1832666 | Kabel T2 | 1.S mezipatro
1832673 | 1.S mezipatro | TK.1832673 | Kabel T2 | 1.S mezipatro
1832682 | 1.S mezipatro | TK.1832682 | Kabel T2 | 1.S mezipatro
1832689 | 1.S mezipatro | TK.1832689 | Kabel T2 | 1.S mezipatro
1832698 | 1.S mezipatro | TK.1832698 | Kabel T2 | 1.S mezipatro
1832705 | 1.S mezipatro | TK.1832705 | Kabel T2 | 1.S mezipatro
1832714 | 1.S mezipatro | TK.1832714 | Kabel T2 | 1.S mezipatro
1832721 | 1.S mezipatro | TK.1832721 | Kabel T2 | 1.S mezipatro
1832730 | 1.S mezipatro | TK.1832730 | Kabel T2 | 1.S mezipatro
1832737 | 1.S mezipatro | TK.1832737 | Kabel T2 | 1.S mezipatro
1832747 | 1.S mezipatro | TK.1832747 | Kabel T2 | 1.S mezipatro
1832759 | 1.S mezipatro | TK.1832759 | Kabel T2 | 1.S mezipatro
1832766 | 1.S mezipatro | TK.1832766 | Kabel T2 | 1.S mezipatro
1832775 | 1.S mezipatro | TK.1832775 | Kabel T2 | 1.S mezipatro
1832782 | 1.S mezipatro | TK.1832782 | Kabel T2 | 1.S mezipatro
1832791 | 1.S mezipatro | TK.1832791 | Kabel T2 | 1.S mezipatro
1832798 | 1.S mezipatro | TK.1832798 | Kabel T2 | 1.S mezipatro
1832807 | 1.S mezipatro | TK.1832807 | Kabel T2 | 1.S mezipatro
1832814 | 1.S mezipatro | TK.1832814 | Kabel T2 | 1.S mezipatro
1832823 | 1.S mezipatro | TK.1832823 | Kabel T2 | 1.S mezipatro
1832839 | 1.S mezipatro | TK.1832839 | Kabel T2 | 1.S mezipatro
1832960 | 1.S mezipatro | TK.1832960 | Kabel T2 | 1.S mezipatro
1833343 | 1.S mezipatro | TK.1833343 | Kabel T2 | 1.S mezipatro
1833488 | 1.S mezipatro | TK.1833488 | Kabel T2 | 1.S mezipatro
1833497 | 1.S mezipatro | TK.1833497 | Kabel T2 | 1.S mezipatro
1833516 | 1.S mezipatro | TK.1833516 | Kabel T2 | 1.S mezipatro
1833634 | 1.S mezipatro | TK.1833634 | Kabel T2 | 1.S mezipatro
1835401 | 2.NP | TK.1835401 | Kabel T3 | 2.NP
1835408 | 2.NP | TK.1835408 | Kabel T3 | 2.NP
1835422 | 2.NP | TK.1835422 | Kabel T3 | 2.NP
1835431 | 2.NP | TK.1835431 | Kabel T3 | 2.NP
1835438 | 2.NP | TK.1835438 | Kabel T3 | 2.NP
1835447 | 2.NP | TK.1835447 | Kabel T3 | 2.NP
1835454 | 2.NP | TK.1835454 | Kabel T3 | 2.NP
1835463 | 2.NP | TK.1835463 | Kabel T3 | 2.NP
1835470 | 2.NP | TK.1835470 | Kabel T3 | 2.NP
1835479 | 2.NP | TK.1835479 | Kabel T3 | 2.NP
1835486 | 2.NP | TK.1835486 | Kabel T3 | 2.NP
1835495 | 2.NP | TK.1835495 | Kabel T3 | 2.NP
1835502 | 2.NP | TK.1835502 | Kabel T3 | 2.NP
1835511 | 2.NP | TK.1835511 | Kabel T3 | 2.NP
1835518 | 2.NP | TK.1835518 | Kabel T3 | 2.NP
1835527 | 2.NP | TK.1835527 | Kabel T3 | 2.NP
1835536 | 2.NP | TK.1835536 | Kabel T3 | 2.NP
1835546 | 2.NP | TK.1835546 | Kabel T3 | 2.NP
1835555 | 2.NP | TK.1835555 | Kabel T3 | 2.NP
1835562 | 2.NP | TK.1835562 | Kabel T3 | 2.NP
1835571 | 2.NP | TK.1835571 | Kabel T3 | 2.NP
1835578 | 2.NP | TK.1835578 | Kabel T3 | 2.NP
1835587 | 2.NP | TK.1835587 | Kabel T3 | 2.NP
1835594 | 2.NP | TK.1835594 | Kabel T3 | 2.NP
1835603 | 2.NP | TK.1835603 | Kabel T3 | 2.NP
1835610 | 2.NP | TK.1835610 | Kabel T3 | 2.NP
1835619 | 2.NP | TK.1835619 | Kabel T3 | 2.NP
1835635 | 2.NP | TK.1835635 | Kabel T3 | 2.NP
1835654 | 2.NP | TK.1835654 | Kabel T3 | 2.NP
1835670 | 2.NP | TK.1835670 | Kabel T3 | 2.NP
1836518 | 2.NP | TK.1836518 | Kabel T3 | 2.NP
1837518 | 3.NP | TK.1837518 | Kabel T4 | 3.NP
1837525 | 3.NP | TK.1837525 | Kabel T4 | 3.NP
1837532 | 3.NP | TK.1837532 | Kabel T4 | 3.NP
1837541 | 3.NP | TK.1837541 | Kabel T4 | 3.NP
1837548 | 3.NP | TK.1837548 | Kabel T4 | 3.NP
1837557 | 3.NP | TK.1837557 | Kabel T4 | 3.NP
1837564 | 3.NP | TK.1837564 | Kabel T4 | 3.NP
1837573 | 3.NP | TK.1837573 | Kabel T4 | 3.NP
1837580 | 3.NP | TK.1837580 | Kabel T4 | 3.NP
1837589 | 3.NP | TK.1837589 | Kabel T4 | 3.NP
1837596 | 3.NP | TK.1837596 | Kabel T4 | 3.NP
1837605 | 3.NP | TK.1837605 | Kabel T4 | 3.NP
1837612 | 3.NP | TK.1837612 | Kabel T4 | 3.NP
1837621 | 3.NP | TK.1837621 | Kabel T4 | 3.NP
1837628 | 3.NP | TK.1837628 | Kabel T4 | 3.NP
1837637 | 3.NP | TK.1837637 | Kabel T4 | 3.NP
1837644 | 3.NP | TK.1837644 | Kabel T4 | 3.NP
1837651 | 3.NP | TK.1837651 | Kabel T4 | 3.NP
1837660 | 3.NP | TK.1837660 | Kabel T4 | 3.NP
1837667 | 3.NP | TK.1837667 | Kabel T4 | 3.NP
1837676 | 3.NP | TK.1837676 | Kabel T4 | 3.NP
1837683 | 3.NP | TK.1837683 | Kabel T4 | 3.NP
1837692 | 3.NP | TK.1837692 | Kabel T4 | 3.NP
1837699 | 3.NP | TK.1837699 | Kabel T4 | 3.NP
1837708 | 3.NP | TK.1837708 | Kabel T4 | 3.NP
1837715 | 3.NP | TK.1837715 | Kabel T4 | 3.NP
1837724 | 3.NP | TK.1837724 | Kabel T4 | 3.NP
1837740 | 3.NP | TK.1837740 | Kabel T4 | 3.NP
1837750 | 3.NP | TK.1837750 | Kabel T4 | 3.NP
1837772 | 3.NP | TK.1837772 | Kabel T4 | 3.NP
1837903 | 3.NP | TK.1837903 | Kabel T4 | 3.NP
1838282 | 4.NP | TK.1838282 | Kabel T5 | 4.NP
1838289 | 4.NP | TK.1838289 | Kabel T5 | 4.NP
1838296 | 4.NP | TK.1838296 | Kabel T5 | 4.NP
1838305 | 4.NP | TK.1838305 | Kabel T5 | 4.NP
1838312 | 4.NP | TK.1838312 | Kabel T5 | 4.NP
1838321 | 4.NP | TK.1838321 | Kabel T5 | 4.NP
1838328 | 4.NP | TK.1838328 | Kabel T5 | 4.NP
1838337 | 4.NP | TK.1838337 | Kabel T5 | 4.NP
1838344 | 4.NP | TK.1838344 | Kabel T5 | 4.NP
1838353 | 4.NP | TK.1838353 | Kabel T5 | 4.NP
1838360 | 4.NP | TK.1838360 | Kabel T5 | 4.NP
1838369 | 4.NP | TK.1838369 | Kabel T5 | 4.NP
1838376 | 4.NP | TK.1838376 | Kabel T5 | 4.NP
1838385 | 4.NP | TK.1838385 | Kabel T5 | 4.NP
1838392 | 4.NP | TK.1838392 | Kabel T5 | 4.NP
1838401 | 4.NP | TK.1838401 | Kabel T5 | 4.NP
1838408 | 4.NP | TK.1838408 | Kabel T5 | 4.NP
1838415 | 4.NP | TK.1838415 | Kabel T5 | 4.NP
1838424 | 4.NP | TK.1838424 | Kabel T5 | 4.NP
1838431 | 4.NP | TK.1838431 | Kabel T5 | 4.NP
1838440 | 4.NP | TK.1838440 | Kabel T5 | 4.NP
1838447 | 4.NP | TK.1838447 | Kabel T5 | 4.NP
1838456 | 4.NP | TK.1838456 | Kabel T5 | 4.NP
1838463 | 4.NP | TK.1838463 | Kabel T5 | 4.NP
1838472 | 4.NP | TK.1838472 | Kabel T5 | 4.NP
1838479 | 4.NP | TK.1838479 | Kabel T5 | 4.NP
1838488 | 4.NP | TK.1838488 | Kabel T5 | 4.NP
1838504 | 4.NP | TK.1838504 | Kabel T5 | 4.NP
1838509 | 4.NP | TK.1838509 | Kabel T5 | 4.NP
1838531 | 4.NP | TK.1838531 | Kabel T5 | 4.NP
1838720 | 4.NP | TK.1838720 | Kabel T5 | 4.NP
1838837 | 3.NP mezipatro | TK.1838837 | Kabel T5 | 3.NP mezipatro
1838844 | 3.NP mezipatro | TK.1838844 | Kabel T5 | 3.NP mezipatro
1838851 | 3.NP mezipatro | TK.1838851 | Kabel T5 | 3.NP mezipatro
1838860 | 3.NP mezipatro | TK.1838860 | Kabel T5 | 3.NP mezipatro
1838867 | 3.NP mezipatro | TK.1838867 | Kabel T5 | 3.NP mezipatro
1838876 | 3.NP mezipatro | TK.1838876 | Kabel T5 | 3.NP mezipatro
1838902 | 3.NP mezipatro | TK.1838902 | Kabel T5 | 3.NP mezipatro
1838909 | 3.NP mezipatro | TK.1838909 | Kabel T5 | 3.NP mezipatro
1838918 | 3.NP mezipatro | TK.1838918 | Kabel T5 | 3.NP mezipatro
1838927 | 3.NP mezipatro | TK.1838927 | Kabel T5 | 3.NP mezipatro
1838934 | 3.NP mezipatro | TK.1838934 | Kabel T5 | 3.NP mezipatro
1838943 | 3.NP mezipatro | TK.1838943 | Kabel T5 | 3.NP mezipatro
1838950 | 3.NP mezipatro | TK.1838950 | Kabel T5 | 3.NP mezipatro
1838959 | 3.NP mezipatro | TK.1838959 | Kabel T5 | 3.NP mezipatro
1838966 | 3.NP mezipatro | TK.1838966 | Kabel T5 | 3.NP mezipatro
1838975 | 3.NP mezipatro | TK.1838975 | Kabel T5 | 3.NP mezipatro
1838982 | 3.NP mezipatro | TK.1838982 | Kabel T5 | 3.NP mezipatro
1838991 | 3.NP mezipatro | TK.1838991 | Kabel T5 | 3.NP mezipatro
1839000 | 3.NP mezipatro | TK.1839000 | Kabel T5 | 3.NP mezipatro
1839009 | 3.NP mezipatro | TK.1839009 | Kabel T5 | 3.NP mezipatro
1839018 | 3.NP mezipatro | TK.1839018 | Kabel T5 | 3.NP mezipatro
1839025 | 3.NP mezipatro | TK.1839025 | Kabel T5 | 3.NP mezipatro
1839034 | 3.NP mezipatro | TK.1839034 | Kabel T5 | 3.NP mezipatro
1839041 | 3.NP mezipatro | TK.1839041 | Kabel T5 | 3.NP mezipatro
