Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement []
File name: Y:\02_zakazky\A-22-1042_Parkovaci dum Trutnov\15_CD\2025-07-18_CD_A-22-1042_Parkovaci dum Trutnov_DPS - REV.1\model\ifc\SO01-ZOV.ifc
Time: 2025-07-18T16:55:47+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativní uživatelské rozhraní 20.2.12.1

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Podlaží:#Hlavní (2)
Name | LongName | Elevation (mm)
B.p.v | B.p.v | 0
1NP | 1NP | 439500

# IfcBuildingElementProxy: #Mobilní toaleta:1050x1050 (2)
In: 1NP
Type - Material: #Plast, bílý, #Plast, zelený
Type - CZ_ElementCommon - ElementProjectSpecificName: 1050x1050; ElementProjectSpecificDescription: Mobilní toaleta; ElementProjectSpecificIdentifier: WC
Type - CZ_DTcommon - DT_name: mobilní toalety
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; StoreyProjectSpecificIdentifier: 1NP
Name (#Mobilní toaleta:1050x1050:...) | Reference
294132 | WC.294132
294715 | WC.294715

# IfcBuildingElementProxy: #Obecný předmět, liniový:kontejnery (3)
In: 1NP
Type - Material: #Hliník
Type - CZ_ElementCommon - ElementProjectSpecificName: kontejnery; ElementProjectSpecificDescription: Kontejnery pro odpad; ElementProjectSpecificIdentifier: ZOV - 02
Type - CZ_DTcommon - DT_name: kontejnery
Type - CZ_CCI - CCI_FunctionalSystemsCode: S; CCI_TechnicalSystemsCode: RB; CCI_ComponentsCode: CNA
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01
Name (#Obecný předmět, liniový:kontejnery:...) | Reference
282418 | ZOV - 02.282418
283552 | ZOV - 02.283552
283578 | ZOV - 02.283578

# IfcBuildingElementProxy: #Skládka:#Skládka, #Skládka:#Skládka:271309
In: 1NP
Type - Material: #Nespecifikováno
Type - CZ_ElementCommon - ElementProjectSpecificName: Skládka; ElementProjectSpecificDescription: Skládka deponie; ElementProjectSpecificIdentifier: ZOV - 04
Type - CZ_DTcommon - DT_name: skládky materiálu / zeminy
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; Reference: ZOV - 04.271309
CZ_CCI - CCI_BuiltSpacesCode: CAL

# IfcBuildingElementProxy: #Stavební buňka:#Stavební buňka (4)
In: 1NP
Type - Material: #Plech, modrý (3), #Sklo, #Dřevo
Type - CZ_ElementCommon - ElementProjectSpecificName: Stavební buňka; ElementProjectSpecificDescription: Stavební buňka pro TDS/BIM koordinatora s klimatizací, patrová buňka včetně schodiště a zábradlí pro přístup; ElementProjectSpecificIdentifier: ZOV - 06
Type - CZ_DTcommon - DT_name: stavební buňky
Type - CZ_CCI - CCI_FunctionalSystemsCode: S; CCI_TechnicalSystemsCode: RB; CCI_ComponentsCode: CFA
Material: #Plech, modrý, #Sklo, #Dřevo
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01
Name (#Stavební buňka:#Stavební buňka:...) | Reference
249839 | ZOV - 06.249839
249842 | ZOV - 06.249842
249848 | ZOV - 06.249848
296559 | ZOV - 06.296559

# IfcBuildingElementProxy: #Stavební buňka:#Stavební buňka - pro INV, #Stavební buňka:#Stavební buňka - pro INV:249845
In: 1NP
Type - Material: #Plech, modrý (3), #Sklo, #Dřevo
Type - CZ_ElementCommon - ElementProjectSpecificName: Stavební buňka - pro INV; ElementProjectSpecificDescription: Stavební buňka pro investora (vybavení - zasedací místnosti, kávovar, lednice, WIFI připojení, plátno/LCD panel, klimatizace); ElementProjectSpecificIdentifier: ZOV 07
Type - CZ_DTcommon - DT_name: stavební buňky
Type - CZ_CCI - CCI_FunctionalSystemsCode: S; CCI_TechnicalSystemsCode: RB; CCI_ComponentsCode: CFA
Material: #Plech, modrý, #Sklo, #Dřevo
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; Reference: ZOV 07.249845

# IfcBuildingElementProxy: Podlaha:ZOV - jeřáb, Podlaha:ZOV - jeřáb:292761
In: B.p.v
Type - CZ_ElementCommon - ElementProjectSpecificName: ZOV - jeřáb; ElementProjectSpecificDescription: Jeřáb; ElementProjectSpecificIdentifier: ZOV04
Type - CZ_DTcommon - DT_name: plochy
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; Reference: ZOV04.292761
CZ_CCI - CCI_BuiltSpacesCode: DCA

# IfcBuildingElementProxy: Podlaha:ZOV - plocha pro parkování vozidel stavby, Podlaha:ZOV - plocha pro parkování vozidel stavby:292748
In: B.p.v
Type - CZ_ElementCommon - ElementProjectSpecificName: ZOV - plocha pro parkování vozidel stavby; ElementProjectSpecificDescription: Plocha pro parkování; ElementProjectSpecificIdentifier: ZOV05
Type - CZ_DTcommon - DT_name: plochy
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; Reference: ZOV05.292748
CZ_CCI - CCI_BuiltSpacesCode: CBD

# IfcBuildingElementProxy: Podlaha:ZOV - plocha pro skládku materiálů, Podlaha:ZOV - plocha pro skládku materiálů:292762
In: 1NP
Type - CZ_ElementCommon - ElementProjectSpecificName: ZOV - plocha pro skládku materiálů; ElementProjectSpecificDescription: Plocha pro skládku, plocha bude na podlaze opatřeba OSB deskami.; ElementProjectSpecificIdentifier: ZOV01
Type - CZ_DTcommon - DT_name: plochy
Type - CZ_CCI - CCI_FunctionalSystemsCode: X; CCI_TechnicalSystemsCode: X; CCI_ComponentsCode: X
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; Reference: ZOV01.292762
CZ_CCI - CCI_BuiltSpacesCode: CAL

# IfcRailing: Zábradlí:#Zábradlí z pásové oceli, s průběžnými sloupky - Bránka vstup pro pěší, Zábradlí:#Zábradlí z pásové oceli, s průběžnými sloupky - Bránka vstup pro pěší:293363
In: 1NP
Material: #Nespecifikováno
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; Reference: ZOV - 03a.293363; ElementProjectSpecificName: Zábradlí z pásové oceli, s průběžnými sloupky - Bránka vstup pro pěší; ElementProjectSpecificDescription: Oplocení staveniště - branka, vstup pro pěší; ElementProjectSpecificIdentifier: ZOV - 03a; sets with these values: 2
CZ_DTcommon - DT_name: oplocení staveniště; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: S; CCI_TechnicalSystemsCode: RB; CCI_ComponentsCode: RUA; sets with these values: 2

# IfcRailing: Zábradlí:#Zábradlí z pásové oceli, s průběžnými sloupky - vjezdová brána (7)
In: 1NP
Material: #Nespecifikováno
CZ_ElementCommon - ElementProjectObjectIdentifier: SO01; ElementProjectSpecificName: Zábradlí z pásové oceli, s průběžnými sloupky - vjezdová brána; ElementProjectSpecificDescription: Ochranné prvky pro ochranu CO2; ElementProjectSpecificIdentifier: ZOV-03d; sets with these values: 2
CZ_DTcommon - DT_name: oplocení staveniště; sets with these values: 2
CZ_CCI - CCI_FunctionalSystemsCode: S; CCI_TechnicalSystemsCode: RB; CCI_ComponentsCode: RUA; sets with these values: 2
Name (Zábradlí:#Zábradlí z pásové oceli, s průběžnými sloupky - vjezdová brána:...) | Reference
278250 | ZOV-03d.278250
280935 | ZOV-03d.280935
281054 | ZOV-03d.281054
293324 | ZOV-03d.293324
293544 | ZOV-03d.293544
303085 | ZOV-03d.303085
303334 | ZOV-03d.303334
